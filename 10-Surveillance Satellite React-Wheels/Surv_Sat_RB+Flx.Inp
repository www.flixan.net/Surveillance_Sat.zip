Sensitive Instrument 2           40103     0.56641D-02   0.93414D-01  -0.99188D-01  -0.58596D-01  -0.52920D-03  -0.34277D-02
Sensitive Instrument 3           40104     0.21529D-02   0.97290D-01  -0.37974D-01  -0.57415D-01  -0.70116D-05  -0.32873D-02
Sensitive Instrument 4           40105     0.29861D-02   0.96901D-01  -0.52582D-01  -0.57468D-01  -0.98028D-04  -0.32861D-02
Sensitive Instrument 5           40106     0.29999D-02   0.88971D-01  -0.52589D-01  -0.57468D-01  -0.98437D-04  -0.32851D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.21090D-02   0.49200D-01  -0.37852D-01
Accelerometers                   31002     0.21090D-02   0.49200D-01  -0.37852D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.58598D-03  -0.18296D+00   0.67412D-03  -0.27664D-01   0.11115D-02   0.44791D-01

MODE# 16/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    179.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.16261D-02  -0.54071D+00  -0.13084D-02  -0.53093D-01  -0.93551D-03   0.50581D-01
RCS Jet #2    (+X)               98002    -0.61782D-02  -0.16121D+00  -0.57485D-03  -0.67322D-01  -0.68129D-03   0.54516D-01
RCS Jet #3    (+Y)               98003     0.10075D+00   0.97523D-01   0.92727D-01  -0.62880D-01   0.15902D-01   0.49038D-01
RCS Jet #4    (-Y)               98004    -0.11374D+00   0.97434D-01  -0.90497D-01  -0.63305D-01  -0.15289D-01   0.47621D-01
RCS Jet #5    (-Y)               98005    -0.44002D-01  -0.12958D+00  -0.47958D-01  -0.67614D-01  -0.59213D-03   0.52262D-01
RCS Jet #6    (+Y)               98006     0.31870D-01  -0.12963D+00   0.47521D-01  -0.67424D-01  -0.86845D-03   0.52854D-01
RCS Jet #7    (+X)               98007    -0.47804D-02  -0.44478D+00  -0.21007D-03   0.40841D-01   0.23621D-03   0.24595D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.90183D-02  -0.26638D+00  -0.22111D-02  -0.60487D-01  -0.96779D-03   0.82404D-01
Reaction Wheel #2 CG             58042     0.43354D-01  -0.19611D+00   0.56780D-01  -0.73826D-01  -0.15799D-02   0.64336D-01
Reaction Wheel #3 CG             58043    -0.49951D-01  -0.19122D+00  -0.51006D-01  -0.71734D-01   0.31451D-02   0.59724D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.16051D+00   0.18413D+00   0.13973D+00  -0.11617D+00   0.23850D-01   0.70908D-01
Cryo Cooler Pump                 40101     0.16051D+00   0.18413D+00   0.13973D+00  -0.11617D+00   0.23850D-01   0.70908D-01
Cryo Cooler Pump                 40101     0.16051D+00   0.18413D+00   0.13973D+00  -0.11617D+00   0.23850D-01   0.70908D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Second Mirror                    40102     0.18890D+00   0.32885D+00   0.13759D+00  -0.11640D+00   0.24653D-01   0.70578D-01
Second Mirror                    40102     0.18890D+00   0.32885D+00   0.13759D+00  -0.11640D+00   0.24653D-01   0.70578D-01
Sensitive Instrument 2           40103    -0.14275D+00   0.10732D+00  -0.13017D+00  -0.77750D-01  -0.27569D-02   0.79259D-01
Sensitive Instrument 2           40103    -0.14275D+00   0.10732D+00  -0.13017D+00  -0.77750D-01  -0.27569D-02   0.79259D-01
Sensitive Instrument 3           40104    -0.58661D-01   0.15663D+00  -0.48906D-01  -0.75072D-01  -0.88282D-03   0.79777D-01
Sensitive Instrument 4           40105    -0.78994D-01   0.16607D+00  -0.67888D-01  -0.75223D-01  -0.11433D-02   0.79754D-01
Sensitive Instrument 5           40106    -0.78833D-01   0.15029D+00  -0.67961D-01  -0.75226D-01  -0.11473D-02   0.79757D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.57745D-01   0.97678D-01  -0.48057D-01
Accelerometers                   31002    -0.57745D-01   0.97678D-01  -0.48057D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.47018D-02  -0.45287D+00  -0.21560D-03   0.40837D-01   0.23534D-03   0.24598D+00

MODE# 17/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    183.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.18811D+00  -0.23853D-01  -0.71068D-01  -0.20161D-02  -0.24462D-01   0.35854D-02
RCS Jet #2    (+X)               98002     0.37233D-02  -0.84561D-02  -0.80182D-01  -0.27366D-02  -0.29969D-01   0.36589D-02
RCS Jet #3    (+Y)               98003     0.50979D-02   0.62189D-02   0.32209D-01  -0.36427D-02  -0.33233D-01   0.36103D-02
RCS Jet #4    (-Y)               98004    -0.63778D-02   0.56450D-02   0.25006D-01  -0.13315D-02  -0.34026D-01   0.34375D-02
RCS Jet #5    (-Y)               98005     0.67439D-02  -0.42710D-02  -0.64906D-01  -0.28039D-02  -0.29664D-01  -0.12694D-01
RCS Jet #6    (+Y)               98006     0.11567D-01  -0.82551D-02  -0.60923D-01  -0.28223D-02  -0.29345D-01   0.18890D-01
RCS Jet #7    (+X)               98007     0.10338D+00  -0.19859D-01  -0.76393D-01   0.12894D-02  -0.26732D-01   0.11086D-01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.10234D+00  -0.10301D-01  -0.38057D-01  -0.33340D-02  -0.32543D-01   0.24547D-02
Reaction Wheel #2 CG             58042     0.10328D+00  -0.78564D-02   0.37486D-02  -0.48883D-02  -0.27667D-01   0.10093D-01
Reaction Wheel #3 CG             58043     0.96899D-01  -0.50646D-02   0.20213D-02  -0.11517D-02  -0.28446D-01  -0.12043D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.66392D-01   0.71174D-02  -0.10461D-01  -0.63797D-02  -0.51517D-01   0.10436D-01
Cryo Cooler Pump                 40101    -0.66392D-01   0.71174D-02  -0.10461D-01  -0.63797D-02  -0.51517D-01   0.10436D-01
Cryo Cooler Pump                 40101    -0.66392D-01   0.71174D-02  -0.10461D-01  -0.63797D-02  -0.51517D-01   0.10436D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Second Mirror                    40102    -0.12853D+00   0.14268D-01  -0.10632D-01  -0.56976D-02  -0.51761D-01   0.11068D-01
Second Mirror                    40102    -0.12853D+00   0.14268D-01  -0.10632D-01  -0.56976D-02  -0.51761D-01   0.11068D-01
Sensitive Instrument 2           40103    -0.56297D-01   0.51371D-02  -0.24962D-01  -0.35017D-02  -0.32628D-01   0.33839D-02
Sensitive Instrument 2           40103    -0.56297D-01   0.51371D-02  -0.24962D-01  -0.35017D-02  -0.32628D-01   0.33839D-02
Sensitive Instrument 3           40104    -0.55748D-01   0.73490D-02  -0.40723D-02  -0.32597D-02  -0.32214D-01   0.37598D-02
Sensitive Instrument 4           40105    -0.56710D-01   0.77970D-02  -0.10926D-02  -0.32875D-02  -0.32248D-01   0.37276D-02
Sensitive Instrument 5           40106    -0.52142D-01   0.70920D-02  -0.31619D-02  -0.32876D-02  -0.32249D-01   0.37277D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.28631D-01   0.48049D-02  -0.20775D-02
Accelerometers                   31002    -0.28631D-01   0.48049D-02  -0.20775D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.94471D-01  -0.20040D-01  -0.75790D-01   0.12893D-02  -0.26724D-01   0.11087D-01

MODE# 18/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    222.22       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.35707D-02   0.10470D+00   0.27445D-02   0.74395D-02   0.12562D-02  -0.11690D-01
RCS Jet #2    (+X)               98002     0.41034D-02   0.63730D-01   0.23774D-02   0.94111D-02   0.11439D-02  -0.16243D-01
RCS Jet #3    (+Y)               98003    -0.42547D-01  -0.37964D-01  -0.14753D-01   0.82696D-02  -0.83101D-02  -0.15896D-01
RCS Jet #4    (-Y)               98004     0.51293D-01  -0.37859D-01   0.11799D-01   0.84107D-02   0.10018D-01  -0.14962D-01
RCS Jet #5    (-Y)               98005     0.15776D-01   0.54547D-01   0.82284D-02   0.92603D-02   0.53179D-03  -0.16908D-01
RCS Jet #6    (+Y)               98006    -0.73933D-02   0.54469D-01  -0.47531D-02   0.91606D-02   0.18133D-02  -0.16370D-01
RCS Jet #7    (+X)               98007     0.93813D-03   0.12385D+00   0.27868D-02  -0.37296D-01   0.14608D-02  -0.10202D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.25582D-02   0.55122D-01   0.10842D-02   0.86708D-02   0.13495D-02  -0.31007D-01
Reaction Wheel #2 CG             58042    -0.17015D-01   0.27864D-01  -0.10809D-01   0.13624D-01   0.33509D-03  -0.25969D-01
Reaction Wheel #3 CG             58043     0.17583D-01   0.25617D-01   0.86788D-02   0.12888D-01   0.14153D-02  -0.24820D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01
Cryo Cooler Pump                 40101    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01
Cryo Cooler Pump                 40101    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Second Mirror                    40102    -0.99949D-01  -0.89154D-01  -0.29045D-01   0.32200D-01  -0.18401D-01  -0.29515D-01
Second Mirror                    40102    -0.99949D-01  -0.89154D-01  -0.29045D-01   0.32200D-01  -0.18401D-01  -0.29515D-01
Sensitive Instrument 2           40103     0.66256D-01  -0.16165D-01   0.24805D-01   0.14534D-01   0.17873D-02  -0.35474D-01
Sensitive Instrument 2           40103     0.66256D-01  -0.16165D-01   0.24805D-01   0.14534D-01   0.17873D-02  -0.35474D-01
Sensitive Instrument 3           40104     0.28605D-01  -0.36282D-01   0.92771D-02   0.13726D-01   0.95616D-03  -0.35728D-01
Sensitive Instrument 4           40105     0.37712D-01  -0.40509D-01   0.12649D-01   0.13784D-01   0.10552D-02  -0.35710D-01
Sensitive Instrument 5           40106     0.37563D-01  -0.36265D-01   0.12716D-01   0.13786D-01   0.10577D-02  -0.35710D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.27635D-01  -0.26464D-01   0.87567D-02
Accelerometers                   31002     0.27635D-01  -0.26464D-01   0.87567D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.14250D-02   0.13399D+00   0.27540D-02  -0.37295D-01   0.14612D-02  -0.10203D+00

MODE# 19/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    225.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.12695D+00  -0.76125D-02  -0.40997D-01  -0.34151D-03  -0.14730D-01   0.26863D-02
RCS Jet #2    (+X)               98002     0.36824D-02  -0.35428D-02  -0.50876D-01  -0.10821D-02  -0.20574D-01   0.21870D-02
RCS Jet #3    (+Y)               98003     0.35599D-02   0.46379D-02   0.26604D-01  -0.20766D-02  -0.26408D-01   0.26394D-02
RCS Jet #4    (-Y)               98004    -0.21576D-02   0.39954D-02   0.25134D-01   0.10711D-02  -0.26557D-01   0.29534D-02
RCS Jet #5    (-Y)               98005     0.98099D-02   0.57123D-03  -0.39892D-01  -0.12221D-02  -0.20408D-01  -0.20198D-01
RCS Jet #6    (+Y)               98006     0.12094D-01  -0.47181D-02  -0.38079D-01  -0.13229D-02  -0.19510D-01   0.21995D-01
RCS Jet #7    (+X)               98007     0.73961D-01  -0.69773D-02  -0.48638D-01   0.75078D-03  -0.19976D-01   0.48721D-02

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.74967D-01  -0.15287D-02  -0.23617D-01  -0.15749D-02  -0.23238D-01   0.28752D-03
Reaction Wheel #2 CG             58042     0.75875D-01  -0.11226D-02   0.70946D-02  -0.35550D-02  -0.18632D-01   0.10591D-01
Reaction Wheel #3 CG             58043     0.71359D-01   0.24035D-02   0.78572D-02   0.15332D-02  -0.20057D-01  -0.22264D-02

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.69803D-01   0.21981D-02  -0.97251D-02  -0.38056D-02  -0.55278D-01   0.12736D-01
Cryo Cooler Pump                 40101    -0.69803D-01   0.21981D-02  -0.97251D-02  -0.38056D-02  -0.55278D-01   0.12736D-01
Cryo Cooler Pump                 40101    -0.69803D-01   0.21981D-02  -0.97251D-02  -0.38056D-02  -0.55278D-01   0.12736D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Second Mirror                    40102    -0.13682D+00   0.57654D-02  -0.98733D-02  -0.27026D-02  -0.55690D-01   0.13754D-01
Second Mirror                    40102    -0.13682D+00   0.57654D-02  -0.98733D-02  -0.27026D-02  -0.55690D-01   0.13754D-01
Sensitive Instrument 2           40103    -0.39441D-01   0.30719D-02  -0.11294D-01  -0.15191D-02  -0.24544D-01   0.94702D-03
Sensitive Instrument 2           40103    -0.39441D-01   0.30719D-02  -0.11294D-01  -0.15191D-02  -0.24544D-01   0.94702D-03
Sensitive Instrument 3           40104    -0.40529D-01   0.37982D-02   0.31325D-02  -0.12684D-02  -0.24108D-01   0.13620D-02
Sensitive Instrument 4           40105    -0.40881D-01   0.39627D-02   0.56603D-02  -0.12941D-02  -0.24139D-01   0.13328D-02
Sensitive Instrument 5           40106    -0.37461D-01   0.36938D-02   0.41113D-02  -0.12942D-02  -0.24142D-01   0.13330D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.19978D-01   0.27808D-02   0.46684D-02
Accelerometers                   31002    -0.19978D-01   0.27808D-02   0.46684D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.67307D-01  -0.71180D-02  -0.48187D-01   0.75072D-03  -0.19967D-01   0.48725D-02

MODE# 20/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    261.47       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.66483D-01  -0.64591D-01  -0.25806D-01  -0.11771D-01  -0.24568D-02  -0.27084D-01
RCS Jet #2    (+X)               98002     0.52681D-01  -0.10771D+00  -0.36939D-01   0.61284D-01  -0.27631D-01   0.60868D-01
RCS Jet #3    (+Y)               98003     0.67370D-01  -0.83417D-01  -0.34309D-01   0.52474D-02   0.10123D-02  -0.18437D-01
RCS Jet #4    (-Y)               98004     0.13700D-01  -0.78548D-01  -0.46807D-01  -0.16456D-01   0.10301D+00  -0.58080D-02
RCS Jet #5    (-Y)               98005    -0.89782D-01  -0.11219D+00   0.30945D-01   0.73025D-01  -0.30523D-02   0.35484D+00
RCS Jet #6    (+Y)               98006     0.47541D-01  -0.60755D-01  -0.75326D-01   0.76278D-01  -0.65462D-01  -0.69604D-01
RCS Jet #7    (+X)               98007     0.11154D+00  -0.46748D-01   0.89206D-01  -0.65430D-01   0.15602D+00   0.92130D-02

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.88784D-01  -0.55320D-01  -0.43847D-03   0.21899D-01  -0.96641D-02  -0.31322D-01
Reaction Wheel #2 CG             58042     0.62969D-01  -0.83875D-01  -0.91308D-02   0.23426D-02   0.26150D-02  -0.17278D-02
Reaction Wheel #3 CG             58043     0.35789D-01  -0.80964D-01   0.35163D-02   0.13603D-01   0.23719D-01   0.22984D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.21783D+00  -0.32337D+00  -0.21304D-01   0.22922D+00   0.12024D+00  -0.18770D-02
Cryo Cooler Pump                 40101     0.21783D+00  -0.32337D+00  -0.21304D-01   0.22922D+00   0.12024D+00  -0.18770D-02
Cryo Cooler Pump                 40101     0.21783D+00  -0.32337D+00  -0.21304D-01   0.22922D+00   0.12024D+00  -0.18770D-02

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Second Mirror                    40102     0.36252D+00  -0.61310D+00  -0.16393D-01   0.22399D+00   0.12032D+00  -0.57643D-02
Second Mirror                    40102     0.36252D+00  -0.61310D+00  -0.16393D-01   0.22399D+00   0.12032D+00  -0.57643D-02
Sensitive Instrument 2           40103     0.52097D-01  -0.13339D+00   0.50679D-01   0.34297D-01   0.19434D-01   0.16402D-01
Sensitive Instrument 2           40103     0.52097D-01  -0.13339D+00   0.50679D-01   0.34297D-01   0.19434D-01   0.16402D-01
Sensitive Instrument 3           40104     0.69727D-01  -0.12601D+00   0.88406D-02   0.29056D-01   0.17054D-01   0.15022D-01
Sensitive Instrument 4           40105     0.65927D-01  -0.12424D+00   0.14176D-01   0.29246D-01   0.17376D-01   0.15037D-01
Sensitive Instrument 5           40106     0.63467D-01  -0.12106D+00   0.15291D-01   0.29250D-01   0.17382D-01   0.15034D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.54801D-01  -0.97760D-01   0.67570D-02
Accelerometers                   31002     0.54801D-01  -0.97760D-01   0.67570D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.16355D+00  -0.24728D-01   0.85692D-01  -0.65430D-01   0.15601D+00   0.92075D-02

MODE# 21/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    282.22       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.66320D-01   0.92400D-01  -0.23428D-01   0.29488D-01  -0.62684D-02   0.23762D-01
RCS Jet #2    (+X)               98002     0.39766D-01   0.67026D-01  -0.34597D-01  -0.50771D-01  -0.33398D-01  -0.32456D-01
RCS Jet #3    (+Y)               98003    -0.27987D-01   0.88738D-02  -0.46427D-01   0.25260D-01   0.11814D+00  -0.18749D-02
RCS Jet #4    (-Y)               98004     0.71349D-01   0.13341D-01  -0.11324D-01  -0.99379D-03  -0.11836D-02  -0.53927D-02
RCS Jet #5    (-Y)               98005     0.33275D-01   0.41559D-01  -0.59737D-01  -0.63236D-01  -0.60556D-01   0.46450D-01
RCS Jet #6    (+Y)               98006    -0.39864D-01   0.71478D-01   0.25911D-01  -0.57356D-01  -0.17052D-01  -0.20107D+00
RCS Jet #7    (+X)               98007     0.12444D+00  -0.32139D-01   0.14066D+00   0.17333D+00   0.21974D+00   0.14966D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.84625D-01   0.38864D-02   0.13614D-01  -0.23304D-01  -0.19769D-01   0.47062D-01
Reaction Wheel #2 CG             58042    -0.81709D-02   0.40103D-01   0.18531D-01   0.97072D-02   0.18163D-01  -0.85334D-01
Reaction Wheel #3 CG             58043     0.61730D-01   0.39304D-01   0.12969D-01   0.14131D-01  -0.82634D-02  -0.88291D-02

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.12296D+00   0.48332D+00   0.63055D-01  -0.42503D+00   0.11951D+00  -0.12614D+00
Cryo Cooler Pump                 40101     0.12296D+00   0.48332D+00   0.63055D-01  -0.42503D+00   0.11951D+00  -0.12614D+00
Cryo Cooler Pump                 40101     0.12296D+00   0.48332D+00   0.63055D-01  -0.42503D+00   0.11951D+00  -0.12614D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Second Mirror                    40102     0.27492D+00   0.10318D+01   0.54504D-01  -0.42490D+00   0.12409D+00  -0.12875D+00
Second Mirror                    40102     0.27492D+00   0.10318D+01   0.54504D-01  -0.42490D+00   0.12409D+00  -0.12875D+00
Sensitive Instrument 2           40103     0.92792D-01   0.72702D-01  -0.41011D-01  -0.20860D-01   0.75746D-02  -0.24462D-01
Sensitive Instrument 2           40103     0.92792D-01   0.72702D-01  -0.41011D-01  -0.20860D-01   0.75746D-02  -0.24462D-01
Sensitive Instrument 3           40104     0.66568D-01   0.59972D-01  -0.24505D-01  -0.18427D-01   0.73820D-02  -0.25284D-01
Sensitive Instrument 4           40105     0.73013D-01   0.56975D-01  -0.30039D-01  -0.18472D-01   0.72971D-02  -0.25226D-01
Sensitive Instrument 5           40106     0.71981D-01   0.55976D-01  -0.29571D-01  -0.18473D-01   0.73027D-02  -0.25224D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.59052D-01   0.38249D-01  -0.24301D-01
Accelerometers                   31002     0.59052D-01   0.38249D-01  -0.24301D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.19769D+00  -0.86559D-01   0.13571D+00   0.17333D+00   0.21973D+00   0.14969D+00

MODE# 22/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    293.17       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.85283D-01   0.48842D-01   0.21237D-01   0.27426D-02   0.95170D-02  -0.45790D-02
RCS Jet #2    (+X)               98002    -0.29984D-01   0.71475D-02   0.22194D-01   0.38206D-02   0.10320D-01  -0.14717D-01
RCS Jet #3    (+Y)               98003    -0.18484D-01   0.17212D-01  -0.23331D-01   0.71263D-02   0.13642D-01   0.10451D-02
RCS Jet #4    (-Y)               98004    -0.39083D-01   0.14478D-01  -0.17709D-02   0.99368D-02  -0.23233D-02  -0.10309D-01
RCS Jet #5    (-Y)               98005    -0.15593D-01   0.28818D-03   0.18265D-01   0.26669D-02   0.82756D-02  -0.26492D-01
RCS Jet #6    (+Y)               98006    -0.39647D-01  -0.12803D-02   0.13885D-01   0.36293D-02   0.11897D-01  -0.13061D-01
RCS Jet #7    (+X)               98007    -0.69738D-01   0.44697D-01  -0.15126D-02  -0.61982D-02  -0.22600D-01  -0.40786D-01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.70150D-01   0.30340D-01   0.83129D-02   0.36852D-02   0.10258D-01   0.15013D-02
Reaction Wheel #2 CG             58042    -0.66147D-01   0.33959D-01  -0.13053D-01   0.71456D-02   0.20792D-02  -0.13130D-01
Reaction Wheel #3 CG             58043    -0.59970D-01   0.38350D-01  -0.23195D-03   0.72227D-02  -0.39407D-02   0.14196D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.10493D+00   0.61289D-02   0.98063D-02   0.14124D-01   0.10100D+00  -0.20687D-01
Cryo Cooler Pump                 40101     0.10493D+00   0.61289D-02   0.98063D-02   0.14124D-01   0.10100D+00  -0.20687D-01
Cryo Cooler Pump                 40101     0.10493D+00   0.61289D-02   0.98063D-02   0.14124D-01   0.10100D+00  -0.20687D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Second Mirror                    40102     0.22813D+00  -0.76746D-02   0.10286D-01   0.10775D-01   0.10209D+00  -0.23602D-01
Second Mirror                    40102     0.22813D+00  -0.76746D-02   0.10286D-01   0.10775D-01   0.10209D+00  -0.23602D-01
Sensitive Instrument 2           40103    -0.26752D-01  -0.58290D-03   0.96265D-02   0.63161D-02   0.13642D-01   0.10792D-01
Sensitive Instrument 2           40103    -0.26752D-01  -0.58290D-03   0.96265D-02   0.63161D-02   0.13642D-01   0.10792D-01
Sensitive Instrument 3           40104    -0.13645D-01   0.45905D-02  -0.44594D-02   0.62879D-02   0.13786D-01   0.10954D-01
Sensitive Instrument 4           40105    -0.16438D-01   0.58878D-02  -0.44876D-02   0.62818D-02   0.13781D-01   0.10938D-01
Sensitive Instrument 5           40106    -0.18390D-01   0.60759D-02  -0.36033D-02   0.62814D-02   0.13780D-01   0.10938D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.25379D-01   0.10576D-01  -0.46566D-02
Accelerometers                   31002    -0.25379D-01   0.10576D-01  -0.46566D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.77272D-01   0.45847D-01  -0.10039D-02  -0.61972D-02  -0.22600D-01  -0.40789D-01

MODE# 23/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    306.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.51307D-01  -0.31216D-01   0.83142D-01   0.22984D-01   0.19453D-01   0.10293D-01
RCS Jet #2    (+X)               98002     0.56236D-01  -0.19491D+00   0.76059D-01   0.52108D-01   0.25016D-01   0.67080D-01
RCS Jet #3    (+Y)               98003     0.76752D-01  -0.16958D+00   0.11933D-01   0.84684D-02  -0.33563D-01   0.21427D-01
RCS Jet #4    (-Y)               98004     0.56075D-01  -0.16901D+00   0.39545D-01   0.99180D-02   0.47891D-01   0.85697D-02
RCS Jet #5    (-Y)               98005     0.10771D-01  -0.15780D+00   0.10451D+00   0.61345D-01   0.43483D-01   0.64958D-01
RCS Jet #6    (+Y)               98006     0.12807D+00  -0.16750D+00   0.20956D-01   0.56024D-01   0.11153D-01   0.14176D+00
RCS Jet #7    (+X)               98007     0.43470D-02  -0.14826D+00   0.63020D-01   0.30368D-01  -0.44220D-02   0.13210D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.48814D-02  -0.98564D-01   0.58139D-01   0.48564D-01   0.33910D-01  -0.28856D-02
Reaction Wheel #2 CG             58042     0.51117D-01  -0.11997D+00   0.23766D-01   0.15961D-01   0.80377D-02   0.43298D-01
Reaction Wheel #3 CG             58043     0.38131D-02  -0.11273D+00   0.50453D-01   0.34103D-01   0.24706D-01   0.84524D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.48224D+00   0.82295D+00  -0.16459D+00  -0.11457D+01  -0.49565D+00   0.44446D-01
Cryo Cooler Pump                 40101    -0.48224D+00   0.82295D+00  -0.16459D+00  -0.11457D+01  -0.49565D+00   0.44446D-01
Cryo Cooler Pump                 40101    -0.48224D+00   0.82295D+00  -0.16459D+00  -0.11457D+01  -0.49565D+00   0.44446D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Second Mirror                    40102    -0.10754D+01   0.22621D+01  -0.19004D+00  -0.11146D+01  -0.49273D+00   0.62998D-01
Second Mirror                    40102    -0.10754D+01   0.22621D+01  -0.19004D+00  -0.11146D+01  -0.49273D+00   0.62998D-01
Sensitive Instrument 2           40103     0.71919D-01  -0.19256D+00   0.68001D-01   0.29902D-01   0.67172D-02  -0.68000D-02
Sensitive Instrument 2           40103     0.71919D-01  -0.19256D+00   0.68001D-01   0.29902D-01   0.67172D-02  -0.68000D-02
Sensitive Instrument 3           40104     0.63453D-01  -0.19456D+00   0.40976D-01   0.20563D-01   0.29231D-02  -0.83292D-02
Sensitive Instrument 4           40105     0.65611D-01  -0.19555D+00   0.45767D-01   0.20906D-01   0.34644D-02  -0.82675D-02
Sensitive Instrument 5           40106     0.65122D-01  -0.19206D+00   0.45989D-01   0.20914D-01   0.34742D-02  -0.82734D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.65395D-01  -0.18745D+00   0.38927D-01
Accelerometers                   31002     0.65395D-01  -0.18745D+00   0.38927D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.28679D-02  -0.15541D+00   0.63124D-01   0.30365D-01  -0.44074D-02   0.13210D+00

MODE# 24/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    314.43       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.99001D-01   0.25032D+00  -0.91390D-01   0.18942D-01  -0.42041D-01  -0.63836D-01
RCS Jet #2    (+X)               98002    -0.14315D+00   0.61516D-01  -0.67851D-01   0.48668D-01  -0.38600D-01  -0.10289D+00
RCS Jet #3    (+Y)               98003    -0.22102D+00  -0.14863D+00   0.48448D-02   0.25597D-01  -0.29995D-01  -0.34606D-01
RCS Jet #4    (-Y)               98004    -0.99920D-01  -0.16354D+00   0.68237D-01   0.24332D-01  -0.26689D-01  -0.12469D+00
RCS Jet #5    (-Y)               98005    -0.98568D-01  -0.94398D-02  -0.98784D-02   0.48446D-01  -0.32783D-01  -0.18206D-01
RCS Jet #6    (+Y)               98006    -0.23543D+00   0.79499D-02  -0.84981D-01   0.57089D-01  -0.52943D-01  -0.15686D+00
RCS Jet #7    (+X)               98007    -0.77724D-01   0.32453D+00  -0.15009D+00  -0.20107D+00  -0.13592D+00  -0.45845D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.57233D-01   0.70927D-01  -0.37531D-01   0.17063D-01  -0.40897D-01  -0.11212D+00
Reaction Wheel #2 CG             58042    -0.97522D-01  -0.25528D-01  -0.24044D-01   0.35628D-01  -0.54992D-01  -0.90158D-01
Reaction Wheel #3 CG             58043    -0.74935D-02  -0.25587D-01   0.24287D-01   0.38843D-01  -0.28474D-01  -0.79406D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.93351D+00   0.42618D+00   0.20425D+00  -0.41692D+00   0.10308D+01  -0.50328D+00
Cryo Cooler Pump                 40101     0.93351D+00   0.42618D+00   0.20425D+00  -0.41692D+00   0.10308D+01  -0.50328D+00
Cryo Cooler Pump                 40101     0.93351D+00   0.42618D+00   0.20425D+00  -0.41692D+00   0.10308D+01  -0.50328D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Second Mirror                    40102     0.22048D+01   0.10043D+01   0.19780D+00  -0.44737D+00   0.10475D+01  -0.53681D+00
Second Mirror                    40102     0.22048D+01   0.10043D+01   0.19780D+00  -0.44737D+00   0.10475D+01  -0.53681D+00
Sensitive Instrument 2           40103    -0.84927D-01  -0.13930D+00   0.50290D-01   0.47396D-01   0.21949D-01  -0.18607D-01
Sensitive Instrument 2           40103    -0.84927D-01  -0.13930D+00   0.50290D-01   0.47396D-01   0.21949D-01  -0.18607D-01
Sensitive Instrument 3           40104    -0.99753D-01  -0.14923D+00  -0.60206D-02   0.40621D-01   0.20458D-01  -0.16622D-01
Sensitive Instrument 4           40105    -0.95519D-01  -0.15118D+00   0.18135D-02   0.40789D-01   0.20821D-01  -0.16823D-01
Sensitive Instrument 5           40106    -0.98471D-01  -0.14432D+00   0.31494D-02   0.40794D-01   0.20810D-01  -0.16829D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.12006D+00  -0.11679D+00  -0.15440D-02
Accelerometers                   31002    -0.12006D+00  -0.11679D+00  -0.15440D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.12302D+00   0.38125D+00  -0.14704D+00  -0.20106D+00  -0.13595D+00  -0.45850D+00

MODE# 25/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    316.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.57204D-01   0.39286D-01  -0.11399D-01   0.48988D-02  -0.55992D-02   0.57084D-02
RCS Jet #2    (+X)               98002     0.20150D-01  -0.14483D-01  -0.15543D-01   0.91790D-03  -0.86041D-02   0.44314D-03
RCS Jet #3    (+Y)               98003     0.49967D-01   0.45264D-01  -0.51964D-02   0.13036D-01   0.12324D-01   0.35320D-03
RCS Jet #4    (-Y)               98004    -0.12149D-01   0.47862D-01   0.26166D-01   0.11651D-01  -0.21967D-01   0.13660D-01
RCS Jet #5    (-Y)               98005     0.22863D-01  -0.12608D-01  -0.10823D-01  -0.95167D-04  -0.11720D-01  -0.92216D-02
RCS Jet #6    (+Y)               98006     0.19799D-01  -0.13565D-01  -0.10150D-01  -0.64021D-03  -0.48917D-02  -0.21779D-02
RCS Jet #7    (+X)               98007     0.55254D-01   0.41490D-02   0.16350D-01   0.35214D-01   0.34914D-01   0.29388D-01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.50962D-01   0.31565D-01  -0.27297D-02   0.34567D-04  -0.87004D-02   0.18734D-01
Reaction Wheel #2 CG             58042     0.46230D-01   0.60866D-01  -0.39489D-03   0.95998D-02   0.90872D-02   0.22906D-01
Reaction Wheel #3 CG             58043     0.39108D-01   0.62033D-01   0.19068D-01   0.94804D-02  -0.13501D-01   0.17663D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.50371D-01  -0.19692D-01  -0.27177D-01   0.33013D-01  -0.97878D-01   0.66451D-01
Cryo Cooler Pump                 40101    -0.50371D-01  -0.19692D-01  -0.27177D-01   0.33013D-01  -0.97878D-01   0.66451D-01
Cryo Cooler Pump                 40101    -0.50371D-01  -0.19692D-01  -0.27177D-01   0.33013D-01  -0.97878D-01   0.66451D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Second Mirror                    40102    -0.17076D+00  -0.64913D-01  -0.26708D-01   0.35467D-01  -0.99055D-01   0.69499D-01
Second Mirror                    40102    -0.17076D+00  -0.64913D-01  -0.26708D-01   0.35467D-01  -0.99055D-01   0.69499D-01
Sensitive Instrument 2           40103    -0.40182D-01   0.12685D-01   0.97191D-02   0.38360D-02  -0.13747D-01   0.22763D-01
Sensitive Instrument 2           40103    -0.40182D-01   0.12685D-01   0.97191D-02   0.38360D-02  -0.13747D-01   0.22763D-01
Sensitive Instrument 3           40104    -0.17370D-01   0.24028D-01   0.12042D-01   0.45289D-02  -0.13015D-01   0.22835D-01
Sensitive Instrument 4           40105    -0.23192D-01   0.26730D-01   0.14746D-01   0.44954D-02  -0.13072D-01   0.22831D-01
Sensitive Instrument 5           40106    -0.21341D-01   0.25902D-01   0.13907D-01   0.44942D-02  -0.13074D-01   0.22831D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.57294D-02   0.28810D-01   0.12717D-01
Accelerometers                   31002    -0.57294D-02   0.28810D-01   0.12717D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.66892D-01  -0.69293D-02   0.15564D-01   0.35214D-01   0.34916D-01   0.29392D-01

MODE# 26/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    391.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.29669D-01   0.83330D-01   0.24088D-01  -0.55618D-03   0.32708D-02  -0.13319D-01
RCS Jet #2    (+X)               98002     0.99794D-01   0.10425D-01   0.25955D-01   0.11671D-01  -0.13105D-01  -0.28247D-01
RCS Jet #3    (+Y)               98003     0.11454D+00   0.46129D-01  -0.10567D+00   0.76354D-01   0.32437D+00   0.11078D+00
RCS Jet #4    (-Y)               98004     0.52196D-01  -0.36874D-03  -0.66374D-01  -0.45067D-01   0.30858D+00  -0.16216D+00
RCS Jet #5    (-Y)               98005     0.11369D+00  -0.76319D-02   0.40099D-01   0.85949D-02  -0.18311D-01  -0.11264D-01
RCS Jet #6    (+Y)               98006     0.75358D-01  -0.41898D-02   0.24262D-01   0.14519D-01  -0.13780D-01  -0.41081D-01
RCS Jet #7    (+X)               98007     0.82831D-01   0.15615D+00   0.11267D+00  -0.11458D+00   0.11152D+00  -0.25350D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.85807D-01   0.62956D-01   0.19585D-02  -0.10069D-01   0.93949D-03  -0.27439D-01
Reaction Wheel #2 CG             58042     0.27437D-01   0.17575D-01  -0.34945D-01  -0.48398D-02   0.32904D-01  -0.88865D-01
Reaction Wheel #3 CG             58043     0.51600D-01   0.14199D+00   0.34030D-02   0.38392D-01  -0.25028D-02   0.11537D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.51832D-01  -0.32156D-01  -0.85465D-01  -0.78078D-02  -0.18868D+00   0.13102D+00
Cryo Cooler Pump                 40101    -0.51832D-01  -0.32156D-01  -0.85465D-01  -0.78078D-02  -0.18868D+00   0.13102D+00
Cryo Cooler Pump                 40101    -0.51832D-01  -0.32156D-01  -0.85465D-01  -0.78078D-02  -0.18868D+00   0.13102D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Second Mirror                    40102    -0.28455D+00  -0.35336D-01  -0.86352D-01   0.43012D-03  -0.19092D+00   0.13951D+00
Second Mirror                    40102    -0.28455D+00  -0.35336D-01  -0.86352D-01   0.43012D-03  -0.19092D+00   0.13951D+00
Sensitive Instrument 2           40103     0.11759D+00  -0.16158D-01   0.44189D-01   0.26063D-01   0.46619D-01   0.26255D-01
Sensitive Instrument 2           40103     0.11759D+00  -0.16158D-01   0.44189D-01   0.26063D-01   0.46619D-01   0.26255D-01
Sensitive Instrument 3           40104     0.14299D+00  -0.55181D-02  -0.36675D-02   0.21626D-01   0.41622D-01   0.20545D-01
Sensitive Instrument 4           40105     0.13782D+00  -0.31247D-02  -0.30841D-02   0.21940D-01   0.42090D-01   0.20790D-01
Sensitive Instrument 5           40106     0.13187D+00  -0.13497D-02  -0.38304D-03   0.21940D-01   0.42115D-01   0.20788D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.10691D+00   0.11874D-01  -0.10896D-01
Accelerometers                   31002     0.10691D+00   0.11874D-01  -0.10896D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.11999D+00   0.18865D+00   0.11015D+00  -0.11457D+00   0.11150D+00  -0.25354D+00

MODE# 27/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    398.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.28734D-01  -0.69570D+00  -0.22469D-01  -0.52416D-02   0.29524D-02   0.11213D+00
RCS Jet #2    (+X)               98002     0.23344D-01  -0.11104D+00  -0.33529D-01  -0.96374D-01  -0.15079D-01   0.22109D+00
RCS Jet #3    (+Y)               98003    -0.14418D+00  -0.14662D+00   0.14075D+00  -0.13994D+00  -0.10176D+00   0.12625D+00
RCS Jet #4    (-Y)               98004     0.16949D+00  -0.16038D+00  -0.20481D+00  -0.14934D+00   0.16590D+00   0.60776D-01
RCS Jet #5    (-Y)               98005    -0.14452D+00   0.11088D-01  -0.92396D-01  -0.98246D-01  -0.60788D-02   0.25543D+00
RCS Jet #6    (+Y)               98006     0.17182D+00   0.17656D-01   0.39889D-01  -0.91688D-01  -0.30119D-01   0.20000D+00
RCS Jet #7    (+X)               98007     0.24440D-01  -0.14619D+01  -0.53854D-01   0.12431D+01  -0.39672D-01   0.25424D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.44675D-01  -0.50513D+00  -0.46203D-01   0.31952D-01  -0.16807D-01   0.18066D+00
Reaction Wheel #2 CG             58042     0.13698D+00  -0.58133D+00   0.12428D+00  -0.17110D+00  -0.55991D-01   0.35195D-01
Reaction Wheel #3 CG             58043    -0.33903D-01  -0.59074D+00  -0.20532D+00  -0.13954D+00   0.15356D+00  -0.11540D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.15981D+00  -0.45291D-01   0.24890D+00   0.69181D-01   0.62616D-01  -0.16772D+00
Cryo Cooler Pump                 40101    -0.15981D+00  -0.45291D-01   0.24890D+00   0.69181D-01   0.62616D-01  -0.16772D+00
Cryo Cooler Pump                 40101    -0.15981D+00  -0.45291D-01   0.24890D+00   0.69181D-01   0.62616D-01  -0.16772D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Second Mirror                    40102    -0.85482D-01  -0.13262D+00   0.25136D+00   0.68891D-01   0.60020D-01  -0.17021D+00
Second Mirror                    40102    -0.85482D-01  -0.13262D+00   0.25136D+00   0.68891D-01   0.60020D-01  -0.17021D+00
Sensitive Instrument 2           40103     0.26086D+00   0.11429D+00  -0.24707D+00  -0.14066D+00   0.74364D-02  -0.13042D+00
Sensitive Instrument 2           40103     0.26086D+00   0.11429D+00  -0.24707D+00  -0.14066D+00   0.74364D-02  -0.13042D+00
Sensitive Instrument 3           40104     0.12275D+00   0.52589D-01  -0.10757D+00  -0.12838D+00   0.90976D-02  -0.13010D+00
Sensitive Instrument 4           40105     0.15589D+00   0.37186D-01  -0.14124D+00  -0.12886D+00   0.82267D-02  -0.12998D+00
Sensitive Instrument 5           40106     0.15473D+00   0.27268D-01  -0.14071D+00  -0.12886D+00   0.82469D-02  -0.12997D+00

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.10801D+00  -0.60112D-01  -0.10873D+00
Accelerometers                   31002     0.10801D+00  -0.60112D-01  -0.10873D+00

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.11224D-01  -0.18191D+01  -0.52962D-01   0.12430D+01  -0.39672D-01   0.25427D+01

MODE# 28/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    453.24       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.66914D-01   0.35576D+00  -0.42135D-01   0.47634D-01  -0.69220D-02  -0.27007D-01
RCS Jet #2    (+X)               98002    -0.37299D-01  -0.17275D+00  -0.66891D-02   0.95656D-01   0.63775D-02  -0.70182D-01
RCS Jet #3    (+Y)               98003     0.31382D-01  -0.12460D+00  -0.14256D+00   0.75480D-01   0.16885D-01  -0.26977D-01
RCS Jet #4    (-Y)               98004    -0.95794D-01  -0.11966D+00   0.56237D-01   0.76319D-01  -0.23155D-01  -0.19476D-01
RCS Jet #5    (-Y)               98005    -0.30322D-01  -0.23019D+00   0.59333D-01   0.96904D-01   0.13170D-01   0.56734D-01
RCS Jet #6    (+Y)               98006    -0.12764D+00  -0.19997D+00  -0.82558D-01   0.10239D+00  -0.95623D-02  -0.18511D+00
RCS Jet #7    (+X)               98007    -0.11612D+00   0.70815D+00  -0.97842D-01  -0.84022D+00  -0.10013D+00  -0.15650D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.10682D+00   0.11476D+00  -0.14776D-01   0.51984D-01   0.70842D-02  -0.57158D-01
Reaction Wheel #2 CG             58042    -0.15194D+00   0.19345D+00  -0.18952D+00   0.22164D+00   0.39568D-01  -0.63800D-01
Reaction Wheel #3 CG             58043    -0.81393D-01   0.13040D+00   0.42089D-01   0.87400D-01  -0.61418D-01   0.79068D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.52311D-01  -0.15764D+00  -0.12853D+00  -0.22250D+00  -0.34228D-01   0.17424D+00
Cryo Cooler Pump                 40101     0.52311D-01  -0.15764D+00  -0.12853D+00  -0.22250D+00  -0.34228D-01   0.17424D+00
Cryo Cooler Pump                 40101     0.52311D-01  -0.15764D+00  -0.12853D+00  -0.22250D+00  -0.34228D-01   0.17424D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Second Mirror                    40102     0.93841D-02   0.98137D-01  -0.13420D+00  -0.20900D+00  -0.32869D-01   0.17896D+00
Second Mirror                    40102     0.93841D-02   0.98137D-01  -0.13420D+00  -0.20900D+00  -0.32869D-01   0.17896D+00
Sensitive Instrument 2           40103    -0.96235D-01  -0.29509D+00   0.91615D-01   0.10942D+00   0.30637D-01   0.69967D-01
Sensitive Instrument 2           40103    -0.96235D-01  -0.29509D+00   0.91615D-01   0.10942D+00   0.30637D-01   0.69967D-01
Sensitive Instrument 3           40104    -0.21818D-01  -0.25188D+00  -0.11366D-01   0.76163D-01   0.20614D-01   0.67478D-01
Sensitive Instrument 4           40105    -0.38911D-01  -0.24388D+00   0.52798D-02   0.77047D-01   0.22368D-01   0.66953D-01
Sensitive Instrument 5           40106    -0.42081D-01  -0.23725D+00   0.67147D-02   0.77062D-01   0.22361D-01   0.66930D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.44482D-01  -0.17248D+00  -0.67754D-02
Accelerometers                   31002    -0.44482D-01  -0.17248D+00  -0.67754D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.14948D+00   0.95308D+00  -0.95597D-01  -0.84018D+00  -0.10016D+00  -0.15653D+01

MODE# 29/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.28643D+00  -0.46529D-01   0.49764D-02   0.17122D-01   0.96884D-02   0.43859D-01
RCS Jet #2    (+X)               98002     0.97349D-01  -0.16675D+00  -0.11903D+00   0.14801D-01  -0.81494D-01   0.19081D+00
RCS Jet #3    (+Y)               98003     0.81623D-01   0.90365D-01   0.19021D-01   0.28205D-02  -0.84468D-01   0.20050D+00
RCS Jet #4    (-Y)               98004     0.30035D-01   0.58941D-01   0.94213D-01   0.27331D-01  -0.28253D-02   0.90948D-01
RCS Jet #5    (-Y)               98005     0.25075D-01  -0.32306D-01  -0.65249D-01   0.77096D-02  -0.85565D-01   0.53760D-02
RCS Jet #6    (+Y)               98006     0.29114D+00  -0.78198D-01  -0.82012D-01   0.15419D-01  -0.74866D-01   0.36106D+00
RCS Jet #7    (+X)               98007     0.42510D+00  -0.17395D+01   0.24365D+00   0.27089D+01   0.39037D+00   0.44914D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.46577D+00   0.23185D-01  -0.16206D+00   0.95032D-02  -0.19060D+00   0.59422D-01
Reaction Wheel #2 CG             58042     0.43979D+00   0.88562D-01   0.42703D-01  -0.11807D+00   0.15848D+00   0.47197D+00
Reaction Wheel #3 CG             58043     0.29346D+00   0.31705D+00   0.19852D+00   0.18282D+00  -0.19433D+00   0.23518D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.50098D-01  -0.43365D-01  -0.10588D+00  -0.60721D-01  -0.77521D-02  -0.54463D-01
Cryo Cooler Pump                 40101     0.50098D-01  -0.43365D-01  -0.10588D+00  -0.60721D-01  -0.77521D-02  -0.54463D-01
Cryo Cooler Pump                 40101     0.50098D-01  -0.43365D-01  -0.10588D+00  -0.60721D-01  -0.77521D-02  -0.54463D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Second Mirror                    40102     0.45158D-01   0.27638D-01  -0.10762D+00  -0.60060D-01  -0.55044D-02  -0.55657D-01
Second Mirror                    40102     0.45158D-01   0.27638D-01  -0.10762D+00  -0.60060D-01  -0.55044D-02  -0.55657D-01
Sensitive Instrument 2           40103    -0.37549D-01  -0.11436D+00   0.10520D+00   0.85062D-01  -0.42926D-01   0.81619D-02
Sensitive Instrument 2           40103    -0.37549D-01  -0.11436D+00   0.10520D+00   0.85062D-01  -0.42926D-01   0.81619D-02
Sensitive Instrument 3           40104    -0.34542D-01  -0.10954D+00   0.51546D-01   0.67608D-01  -0.49322D-01   0.70103D-02
Sensitive Instrument 4           40105    -0.36274D-01  -0.10870D+00   0.74416D-01   0.68281D-01  -0.48029D-01   0.68154D-02
Sensitive Instrument 5           40106    -0.29470D-01  -0.99456D-01   0.71333D-01   0.68287D-01  -0.48030D-01   0.68014D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.96738D-02  -0.49379D-01   0.53737D-01
Accelerometers                   31002     0.96738D-02  -0.49379D-01   0.53737D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.55521D+00  -0.25417D+01   0.23488D+00   0.27088D+01   0.39044D+00   0.44920D+01

MODE# 30/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    485.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.30326D+00   0.19028D+00  -0.55415D-01  -0.69617D-02  -0.12900D-01  -0.52806D-01
RCS Jet #2    (+X)               98002     0.62076D-02   0.38160D-01  -0.15313D+00   0.39982D-01  -0.84245D-01  -0.20600D+00
RCS Jet #3    (+Y)               98003     0.44991D-01  -0.54459D-01   0.32240D-01   0.27907D-01  -0.75286D-02  -0.10536D+00
RCS Jet #4    (-Y)               98004    -0.87288D-01  -0.75308D-01   0.98247D-01   0.49436D-01  -0.12928D+00  -0.16960D+00
RCS Jet #5    (-Y)               98005     0.18436D+00  -0.68894D-01  -0.75179D-01   0.40554D-01  -0.77885D-01  -0.29905D+00
RCS Jet #6    (+Y)               98006    -0.99585D-01  -0.96644D-01  -0.13637D+00   0.46657D-01  -0.88480D-01  -0.86646D-01
RCS Jet #7    (+X)               98007     0.32889D+00   0.44576D+01   0.95837D-01  -0.71251D+01   0.24359D+00  -0.11672D+02

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.42050D+00   0.12931D+00  -0.21439D+00  -0.16457D+00  -0.25099D+00  -0.36462D+00
Reaction Wheel #2 CG             58042     0.23356D+00  -0.66835D-01   0.71264D-01  -0.10758D+00  -0.30534D-01   0.57498D-01
Reaction Wheel #3 CG             58043     0.31533D+00   0.57092D-01   0.89571D-01   0.14418D+00  -0.12836D-01  -0.21688D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.97613D-01  -0.25174D-01   0.17121D-01  -0.39719D-01   0.32710D-01   0.83238D-01
Cryo Cooler Pump                 40101     0.97613D-01  -0.25174D-01   0.17121D-01  -0.39719D-01   0.32710D-01   0.83238D-01
Cryo Cooler Pump                 40101     0.97613D-01  -0.25174D-01   0.17121D-01  -0.39719D-01   0.32710D-01   0.83238D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Second Mirror                    40102     0.13909D+00   0.25846D-01   0.16491D-01  -0.40529D-01   0.34967D-01   0.81576D-01
Second Mirror                    40102     0.13909D+00   0.25846D-01   0.16491D-01  -0.40529D-01   0.34967D-01   0.81576D-01
Sensitive Instrument 2           40103    -0.27172D+00  -0.73748D-01  -0.38388D-01   0.11588D-01  -0.84546D-01   0.67642D-01
Sensitive Instrument 2           40103    -0.27172D+00  -0.73748D-01  -0.38388D-01   0.11588D-01  -0.84546D-01   0.67642D-01
Sensitive Instrument 3           40104    -0.19716D+00  -0.32729D-01  -0.36140D-02   0.77837D-02  -0.75822D-01   0.76262D-01
Sensitive Instrument 4           40105    -0.21667D+00  -0.23622D-01   0.72763D-02   0.73082D-02  -0.76313D-01   0.75401D-01
Sensitive Instrument 5           40106    -0.20588D+00  -0.27424D-01   0.23789D-02   0.73091D-02  -0.76373D-01   0.75397D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.12548D+00  -0.17153D-01   0.11557D-01
Accelerometers                   31002    -0.12548D+00  -0.17153D-01   0.11557D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.41009D+00   0.65706D+01   0.90367D-01  -0.71249D+01   0.24365D+00  -0.11673D+02

MODE# 31/ 50, Frequency (rad/sec), Damping (zeta), Generalized Mass=    503.65       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.11824D+00   0.14329D+00  -0.66901D-01  -0.43585D-02  -0.22031D-01  -0.76586D-01
RCS Jet #2    (+X)               98002    -0.69028D-01   0.17309D+00  -0.76318D-01  -0.59756D-02  -0.29980D-01  -0.22388D+00
RCS Jet #3    (+Y)               98003    -0.10535D+00  -0.11569D+00   0.61199D-01  -0.15304D-01  -0.77429D-02  -0.17797D+00
RCS Jet #4    (-Y)               98004    -0.29523D-01  -0.11554D+00  -0.90643D-02  -0.10296D-01  -0.74058D-01  -0.16870D+00
RCS Jet #5    (-Y)               98005     0.78538D-01   0.39283D-01  -0.61318D-01  -0.37466D-02  -0.23614D-01  -0.19031D+00
RCS Jet #6    (+Y)               98006    -0.23466D+00   0.45649D-01  -0.57638D-01  -0.13915D-02  -0.37332D-01  -0.24256D+00
RCS Jet #7    (+X)               98007     0.27186D-01  -0.30887D+01  -0.87803D-01   0.55418D+01  -0.38122D-01   0.86597D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.10098D+00   0.19276D-01  -0.11455D+00  -0.13933D+00  -0.14059D+00  -0.30516D+00
Reaction Wheel #2 CG             58042    -0.51261D-01  -0.22465D+00   0.84272D-01  -0.63588D-01  -0.20116D+00  -0.31706D+00
Reaction Wheel #3 CG             58043     0.83709D-01  -0.29528D+00  -0.12412D+00  -0.30181D-01   0.22988D+00  -0.49484D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.55428D-01   0.76952D-01   0.16331D+00   0.70836D-01   0.68712D-01  -0.47182D-01
Cryo Cooler Pump                 40101    -0.55428D-01   0.76952D-01   0.16331D+00   0.70836D-01   0.68712D-01  -0.47182D-01
Cryo Cooler Pump                 40101    -0.55428D-01   0.76952D-01   0.16331D+00   0.70836D-01   0.68712D-01  -0.47182D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Second Mirror                    40102     0.26637D-01   0.58007D-02   0.16580D+00   0.63967D-01   0.67585D-01  -0.50909D-01
Second Mirror                    40102     0.26637D-01   0.58007D-02   0.16580D+00   0.63967D-01   0.67585D-01  -0.50909D-01
Sensitive Instrument 2           40103    -0.12177D+00   0.10587D+00  -0.17709D+00  -0.10026D+00  -0.56873D-01  -0.16532D-01
Sensitive Instrument 2           40103    -0.12177D+00   0.10587D+00  -0.17709D+00  -0.10026D+00  -0.56873D-01  -0.16532D-01
Sensitive Instrument 3           40104    -0.13134D+00   0.99905D-01  -0.58609D-01  -0.77429D-01  -0.41087D-01  -0.54137D-02
Sensitive Instrument 4           40105    -0.13011D+00   0.99336D-01  -0.73287D-01  -0.78749D-01  -0.43194D-01  -0.59492D-02
Sensitive Instrument 5           40106    -0.12400D+00   0.88555D-01  -0.76059D-01  -0.78754D-01  -0.43243D-01  -0.59328D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.92644D-01   0.34018D-01  -0.46082D-01
Accelerometers                   31002    -0.92644D-01   0.34018D-01  -0.46082D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.14504D-01  -0.47416D+01  -0.86943D-01   0.55417D+01  -0.38111D-01   0.86609D+01

MODE# 32/ 51, Frequency (rad/sec), Damping (zeta), Generalized Mass=    507.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.21425D+00   0.53510D-01  -0.30535D-01  -0.60580D-02  -0.36260D-02  -0.38951D-01
RCS Jet #2    (+X)               98002     0.30280D-01   0.13589D-01  -0.10842D+00   0.87521D-02  -0.59977D-01  -0.97350D-01
RCS Jet #3    (+Y)               98003     0.46402D-01  -0.26995D-01   0.47608D-01  -0.32375D-02  -0.15008D-01  -0.75602D-01
RCS Jet #4    (-Y)               98004    -0.35570D-01  -0.41767D-01   0.39138D-01   0.11151D-01  -0.61884D-01  -0.11815D+00
RCS Jet #5    (-Y)               98005     0.13777D+00  -0.28616D-01  -0.66689D-01   0.93812D-02  -0.53658D-01  -0.20879D+00
RCS Jet #6    (+Y)               98006     0.97955D-02  -0.61142D-01  -0.82201D-01   0.12850D-01  -0.61684D-01   0.45235D-01
RCS Jet #7    (+X)               98007     0.30152D+00  -0.21120D+00   0.17465D+00   0.44531D+00   0.31446D+00   0.62705D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.39319D+00   0.14336D-01  -0.20239D+00  -0.12653D+00  -0.24775D+00  -0.23113D+00
Reaction Wheel #2 CG             58042     0.23301D+00  -0.14963D+00   0.10164D+00  -0.14528D+00  -0.10751D-02   0.10687D+00
Reaction Wheel #3 CG             58043     0.24433D+00  -0.81430D-01   0.33745D-02   0.77710D-01   0.10694D+00  -0.29569D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.63099D-01   0.18958D-01   0.57811D-01   0.12464D-01   0.92506D-02   0.51625D-01
Cryo Cooler Pump                 40101     0.63099D-01   0.18958D-01   0.57811D-01   0.12464D-01   0.92506D-02   0.51625D-01
Cryo Cooler Pump                 40101     0.63099D-01   0.18958D-01   0.57811D-01   0.12464D-01   0.92506D-02   0.51625D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Second Mirror                    40102     0.75368D-01   0.98239D-02   0.58468D-01   0.97973D-02   0.10424D-01   0.50682D-01
Second Mirror                    40102     0.75368D-01   0.98239D-02   0.58468D-01   0.97973D-02   0.10424D-01   0.50682D-01
Sensitive Instrument 2           40103    -0.16885D+00   0.10905D-01  -0.75370D-01  -0.29442D-01  -0.70170D-01   0.39246D-01
Sensitive Instrument 2           40103    -0.16885D+00   0.10905D-01  -0.75370D-01  -0.29442D-01  -0.70170D-01   0.39246D-01
Sensitive Instrument 3           40104    -0.12511D+00   0.34219D-01  -0.12949D-01  -0.22580D-01  -0.59906D-01   0.46328D-01
Sensitive Instrument 4           40105    -0.13700D+00   0.39760D-01  -0.11560D-01  -0.23296D-01  -0.60936D-01   0.45769D-01
Sensitive Instrument 5           40106    -0.12838D+00   0.33521D-01  -0.15470D-01  -0.23298D-01  -0.60980D-01   0.45775D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.68290D-01   0.18743D-01  -0.21586D-02
Accelerometers                   31002    -0.68290D-01   0.18743D-01  -0.21586D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.40633D+00  -0.34556D+00   0.16759D+00   0.44530D+00   0.31451D+00   0.62713D+00

MODE# 33/ 52, Frequency (rad/sec), Damping (zeta), Generalized Mass=    527.33       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.12748D+00  -0.88146D-03   0.87665D-01  -0.12014D-02   0.21907D-01  -0.59827D-01
RCS Jet #2    (+X)               98002     0.66565D-01  -0.18575D+00   0.92117D-01   0.29711D-01   0.36502D-01   0.20063D+00
RCS Jet #3    (+Y)               98003     0.16868D+00   0.76755D-01  -0.49709D-01   0.29362D-01   0.87150D-01  -0.78994D-01
RCS Jet #4    (-Y)               98004    -0.64983D-01   0.81131D-01   0.44395D-01   0.19214D-01   0.20942D-01  -0.63684D-01
RCS Jet #5    (-Y)               98005    -0.31373D-01  -0.56650D-01   0.96518D-01   0.36419D-01   0.51013D-01   0.76829D-01
RCS Jet #6    (+Y)               98006     0.32905D+00  -0.11462D+00   0.46102D-01   0.36523D-01   0.30371D-01   0.55122D+00
RCS Jet #7    (+X)               98007     0.96566D-01   0.15700D+01   0.38156D+00  -0.28754D+01   0.41726D+00  -0.44861D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.11700D+00  -0.25441D+00   0.19707D+00   0.36895D+00   0.16560D+00   0.76315D+00
Reaction Wheel #2 CG             58042    -0.23014D+00   0.12143D+00  -0.15256D+00   0.45455D+00  -0.37398D-02  -0.49409D+00
Reaction Wheel #3 CG             58043     0.91005D-02   0.10700D+00   0.18097D+00   0.21644D+00  -0.20442D+00   0.19722D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.17570D+00  -0.24797D-01  -0.92631D-01  -0.22306D-01  -0.63324D-01   0.23106D+00
Cryo Cooler Pump                 40101     0.17570D+00  -0.24797D-01  -0.92631D-01  -0.22306D-01  -0.63324D-01   0.23106D+00
Cryo Cooler Pump                 40101     0.17570D+00  -0.24797D-01  -0.92631D-01  -0.22306D-01  -0.63324D-01   0.23106D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Second Mirror                    40102     0.99320D-01  -0.49797D-02  -0.93608D-01  -0.18569D-01  -0.60931D-01   0.23539D+00
Second Mirror                    40102     0.99320D-01  -0.49797D-02  -0.93608D-01  -0.18569D-01  -0.60931D-01   0.23539D+00
Sensitive Instrument 2           40103    -0.66383D-01  -0.38261D-01   0.15700D+00   0.60874D-01   0.25934D-01   0.90211D-01
Sensitive Instrument 2           40103    -0.66383D-01  -0.38261D-01   0.15700D+00   0.60874D-01   0.25934D-01   0.90211D-01
Sensitive Instrument 3           40104     0.25626D-01   0.57953D-02   0.80614D-01   0.52213D-01   0.22644D-01   0.84090D-01
Sensitive Instrument 4           40105     0.42279D-02   0.15702D-01   0.91199D-01   0.52792D-01   0.23387D-01   0.84580D-01
Sensitive Instrument 5           40106     0.91704D-03   0.17757D-01   0.92700D-01   0.52786D-01   0.23399D-01   0.84574D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.10272D-01   0.49654D-01   0.72915D-01
Accelerometers                   31002     0.10272D-01   0.49654D-01   0.72915D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.23557D+00   0.24278D+01   0.37216D+00  -0.28753D+01   0.41724D+00  -0.44868D+01

MODE# 34/ 53, Frequency (rad/sec), Damping (zeta), Generalized Mass=    528.70       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.76208D-01   0.45136D-02  -0.17904D-01  -0.40328D-02  -0.19967D-02  -0.46373D-02
RCS Jet #2    (+X)               98002     0.10951D-01   0.28825D-01  -0.47109D-01  -0.43097D-02  -0.24222D-01  -0.75383D-01
RCS Jet #3    (+Y)               98003     0.92827D-02  -0.18422D-01   0.22574D-01  -0.70604D-02  -0.20126D-01  -0.13050D-01
RCS Jet #4    (-Y)               98004     0.19813D-05  -0.24692D-01  -0.31831D-02  -0.15295D-02  -0.22230D-01  -0.31925D-01
RCS Jet #5    (-Y)               98005     0.70858D-01  -0.11632D-01  -0.36848D-01  -0.54535D-02  -0.25444D-01  -0.95254D-01
RCS Jet #6    (+Y)               98006    -0.48009D-01  -0.12765D-01  -0.29818D-01  -0.46438D-02  -0.22810D-01  -0.91120D-01
RCS Jet #7    (+X)               98007     0.82511D-01  -0.20400D+00   0.82820D-02   0.38321D+00   0.47356D-01   0.57242D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.19111D+00   0.55682D-01  -0.13444D+00  -0.14112D+00  -0.13598D+00  -0.26743D+00
Reaction Wheel #2 CG             58042     0.13304D+00  -0.54415D-01   0.32510D-01  -0.10548D+00   0.59788D-01   0.19007D+00
Reaction Wheel #3 CG             58043     0.68355D-01  -0.13589D+00  -0.11901D+00  -0.94688D-01   0.21595D+00  -0.26729D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.10811D-01   0.88134D-02   0.39629D-01   0.57456D-02   0.45274D-02   0.14898D-01
Cryo Cooler Pump                 40101     0.10811D-01   0.88134D-02   0.39629D-01   0.57456D-02   0.45274D-02   0.14898D-01
Cryo Cooler Pump                 40101     0.10811D-01   0.88134D-02   0.39629D-01   0.57456D-02   0.45274D-02   0.14898D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Second Mirror                    40102     0.16262D-01   0.47275D-02   0.39943D-01   0.45536D-02   0.46186D-02   0.14536D-01
Second Mirror                    40102     0.16262D-01   0.47275D-02   0.39943D-01   0.45536D-02   0.46186D-02   0.14536D-01
Sensitive Instrument 2           40103    -0.44747D-01   0.13077D-01  -0.62141D-01  -0.25914D-01  -0.26342D-01   0.71851D-02
Sensitive Instrument 2           40103    -0.44747D-01   0.13077D-01  -0.62141D-01  -0.25914D-01  -0.26342D-01   0.71851D-02
Sensitive Instrument 3           40104    -0.36201D-01   0.18111D-01  -0.23439D-01  -0.21269D-01  -0.21664D-01   0.10108D-01
Sensitive Instrument 4           40105    -0.38811D-01   0.19333D-01  -0.26251D-01  -0.21680D-01  -0.22265D-01   0.98347D-02
Sensitive Instrument 5           40106    -0.35660D-01   0.15629D-01  -0.27679D-01  -0.21682D-01  -0.22282D-01   0.98388D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.16530D-01   0.18347D-02  -0.18813D-01
Accelerometers                   31002    -0.16530D-01   0.18347D-02  -0.18813D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.98304D-01  -0.31888D+00   0.72201D-02   0.38320D+00   0.47376D-01   0.57250D+00

MODE# 35/ 54, Frequency (rad/sec), Damping (zeta), Generalized Mass=    529.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.14907D+00  -0.17507D+00   0.63848D-01  -0.41099D-01   0.35218D-01   0.19141D-01
RCS Jet #2    (+X)               98002     0.78346D-01  -0.53442D-01   0.49202D-01  -0.23108D-01   0.15416D-01  -0.95896D-01
RCS Jet #3    (+Y)               98003     0.17387D+00   0.54206D-01  -0.23151D-01  -0.14518D-01  -0.15274D-01   0.65820D-01
RCS Jet #4    (-Y)               98004    -0.85349D-02   0.43690D-01  -0.76539D-01  -0.51398D-02   0.54094D-01   0.28775D-01
RCS Jet #5    (-Y)               98005     0.12850D+00  -0.11202D+00   0.19306D-01  -0.28225D-01  -0.35118D-02  -0.49562D-01
RCS Jet #6    (+Y)               98006    -0.53684D-01  -0.84024D-01   0.61979D-01  -0.31456D-01   0.29208D-01  -0.28380D+00
RCS Jet #7    (+X)               98007    -0.16280D+00   0.25331D+00  -0.23647D+00  -0.63120D+00  -0.38650D+00  -0.96049D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.14271D+00   0.58751D-01   0.96402D-01  -0.32836D-01   0.22984D+00  -0.95474D-01
Reaction Wheel #2 CG             58042     0.26706D+00  -0.85114D-01   0.13707D+00  -0.42978D+00   0.20239D+00   0.71258D+00
Reaction Wheel #3 CG             58043    -0.74476D-01   0.12387D-02  -0.11397D+00  -0.20274D+00   0.63749D-01   0.15776D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.15809D+00  -0.74437D-01  -0.23936D-01  -0.63948D-01  -0.67182D-01   0.28302D+00
Cryo Cooler Pump                 40101     0.15809D+00  -0.74437D-01  -0.23936D-01  -0.63948D-01  -0.67182D-01   0.28302D+00
Cryo Cooler Pump                 40101     0.15809D+00  -0.74437D-01  -0.23936D-01  -0.63948D-01  -0.67182D-01   0.28302D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Second Mirror                    40102     0.74322D-01  -0.10273D-01  -0.25624D-01  -0.54464D-01  -0.66010D-01   0.28885D+00
Second Mirror                    40102     0.74322D-01  -0.10273D-01  -0.25624D-01  -0.54464D-01  -0.66010D-01   0.28885D+00
Sensitive Instrument 2           40103     0.34277D-01  -0.40486D-01  -0.64295D-02   0.17352D-02   0.42283D-01   0.75678D-01
Sensitive Instrument 2           40103     0.34277D-01  -0.40486D-01  -0.64295D-02   0.17352D-02   0.42283D-01   0.75678D-01
Sensitive Instrument 3           40104     0.10788D+00  -0.13983D-02  -0.22600D-01  -0.55756D-02   0.38233D-01   0.66732D-01
Sensitive Instrument 4           40105     0.90957D-01   0.64500D-02  -0.28523D-01  -0.53776D-02   0.38471D-01   0.66968D-01
Sensitive Instrument 5           40106     0.85513D-01   0.13913D-02  -0.26054D-01  -0.53792D-02   0.38498D-01   0.66967D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.71504D-01  -0.32426D-03  -0.30268D-01
Accelerometers                   31002     0.71504D-01  -0.32426D-03  -0.30268D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.29160D+00   0.44215D+00  -0.22776D+00  -0.63118D+00  -0.38648D+00  -0.96064D+00

MODE# 36/ 57, Frequency (rad/sec), Damping (zeta), Generalized Mass=    534.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.13013D+00  -0.10972D+00   0.48007D-01  -0.12695D-01   0.23096D-01   0.12168D-01
RCS Jet #2    (+X)               98002     0.62065D-01  -0.71250D-01   0.55599D-01  -0.14048D-01   0.24406D-01  -0.21140D-01
RCS Jet #3    (+Y)               98003     0.14185D+00   0.47078D-01  -0.26637D-01  -0.97759D-02   0.18670D-01   0.26712D-01
RCS Jet #4    (-Y)               98004    -0.90224D-02   0.43420D-01  -0.64409D-01  -0.85879D-02   0.43630D-01   0.12928D-01
RCS Jet #5    (-Y)               98005     0.64746D-01  -0.86699D-01   0.29965D-01  -0.15484D-01   0.16788D-01   0.12546D-01
RCS Jet #6    (+Y)               98006     0.16859D-01  -0.71890D-01   0.53800D-01  -0.18078D-01   0.29369D-01  -0.10951D+00
RCS Jet #7    (+X)               98007    -0.14462D+00   0.51048D+00  -0.15784D+00  -0.11055D+01  -0.27317D+00  -0.16792D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.17030D+00  -0.41911D-01   0.12204D+00   0.77632D-01   0.21800D+00   0.13601D+00
Reaction Wheel #2 CG             58042     0.11708D+00  -0.71139D-01   0.69864D-01  -0.21745D+00   0.11478D+00   0.36103D+00
Reaction Wheel #3 CG             58043    -0.98536D-01  -0.76529D-01  -0.12309D+00  -0.17459D+00   0.97049D-01   0.77645D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.13478D+00  -0.33748D-01   0.53858D-02  -0.29089D-01  -0.54017D-01   0.24846D+00
Cryo Cooler Pump                 40101     0.13478D+00  -0.33748D-01   0.53858D-02  -0.29089D-01  -0.54017D-01   0.24846D+00
Cryo Cooler Pump                 40101     0.13478D+00  -0.33748D-01   0.53858D-02  -0.29089D-01  -0.54017D-01   0.24846D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Second Mirror                    40102     0.66947D-01  -0.57165D-02   0.45950D-02  -0.23440D-01  -0.53303D-01   0.25302D+00
Second Mirror                    40102     0.66947D-01  -0.57165D-02   0.45950D-02  -0.23440D-01  -0.53303D-01   0.25302D+00
Sensitive Instrument 2           40103     0.29089D-01   0.16619D-02  -0.18698D-01  -0.16825D-01   0.35260D-01   0.63276D-01
Sensitive Instrument 2           40103     0.29089D-01   0.16619D-02  -0.18698D-01  -0.16825D-01   0.35260D-01   0.63276D-01
Sensitive Instrument 3           40104     0.91174D-01   0.33007D-01  -0.18345D-01  -0.16784D-01   0.34316D-01   0.56190D-01
Sensitive Instrument 4           40105     0.76902D-01   0.39612D-01  -0.26600D-01  -0.16817D-01   0.34114D-01   0.56490D-01
Sensitive Instrument 5           40106     0.72074D-01   0.33603D-01  -0.24411D-01  -0.16822D-01   0.34138D-01   0.56495D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.58854D-01   0.21551D-01  -0.25124D-01
Accelerometers                   31002     0.58854D-01   0.21551D-01  -0.25124D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.23565D+00   0.84128D+00  -0.15170D+00  -0.11054D+01  -0.27317D+00  -0.16794D+01

MODE# 37/ 59, Frequency (rad/sec), Damping (zeta), Generalized Mass=    539.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.14551D+00   0.58785D-01  -0.30772D-01   0.59312D-02  -0.10100D-01  -0.58792D-02
RCS Jet #2    (+X)               98002    -0.17026D-01   0.48379D-01  -0.62106D-01   0.40991D-02  -0.26357D-01  -0.34513D-01
RCS Jet #3    (+Y)               98003    -0.49956D-01  -0.32217D-01   0.27140D-01   0.14966D-02  -0.19897D-01  -0.28836D-01
RCS Jet #4    (-Y)               98004     0.34099D-02  -0.34718D-01   0.35738D-01   0.55860D-02  -0.35315D-01  -0.35351D-01
RCS Jet #5    (-Y)               98005     0.28320D-01   0.35960D-01  -0.43236D-01   0.51466D-02  -0.22388D-01  -0.94936D-01
RCS Jet #6    (+Y)               98006    -0.19952D-01   0.20470D-01  -0.49844D-01   0.40330D-02  -0.25109D-01   0.28213D-01
RCS Jet #7    (+X)               98007     0.18361D+00  -0.31102D+00   0.16306D+00   0.66389D+00   0.27788D+00   0.99407D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.28800D+00   0.75729D-01  -0.20323D+00  -0.18817D+00  -0.28343D+00  -0.33989D+00
Reaction Wheel #2 CG             58042     0.72836D-01  -0.32862D-01   0.26926D-01  -0.33882D-01  -0.23788D-01   0.81362D-04
Reaction Wheel #3 CG             58043     0.11011D+00  -0.48968D-01  -0.11646D-01   0.38368D-01   0.10995D+00  -0.24194D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.49134D-01   0.11615D-01  -0.43955D-02   0.13919D-01   0.21852D-01  -0.11940D+00
Cryo Cooler Pump                 40101    -0.49134D-01   0.11615D-01  -0.43955D-02   0.13919D-01   0.21852D-01  -0.11940D+00
Cryo Cooler Pump                 40101    -0.49134D-01   0.11615D-01  -0.43955D-02   0.13919D-01   0.21852D-01  -0.11940D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Second Mirror                    40102    -0.20821D-01  -0.21484D-02  -0.39781D-02   0.10780D-01   0.21966D-01  -0.12161D+00
Second Mirror                    40102    -0.20821D-01  -0.21484D-02  -0.39781D-02   0.10780D-01   0.21966D-01  -0.12161D+00
Sensitive Instrument 2           40103    -0.57472D-01  -0.45732D-02  -0.21564D-01   0.39901D-02  -0.40529D-01  -0.21439D-01
Sensitive Instrument 2           40103    -0.57472D-01  -0.45732D-02  -0.21564D-01   0.39901D-02  -0.40529D-01  -0.21439D-01
Sensitive Instrument 3           40104    -0.77550D-01  -0.13980D-01  -0.45911D-02   0.44854D-02  -0.37632D-01  -0.15930D-01
Sensitive Instrument 4           40105    -0.73530D-01  -0.15820D-01   0.96906D-03   0.42950D-02  -0.37758D-01  -0.16357D-01
Sensitive Instrument 5           40106    -0.68186D-01  -0.14162D-01  -0.14540D-02   0.42968D-02  -0.37783D-01  -0.16358D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.42383D-01  -0.10371D-01   0.22981D-02
Accelerometers                   31002    -0.42383D-01  -0.10371D-01   0.22981D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.27622D+00  -0.51000D+00   0.15681D+00   0.66386D+00   0.27791D+00   0.99421D+00

MODE# 38/ 62, Frequency (rad/sec), Damping (zeta), Generalized Mass=    548.73       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.30150D-01   0.11644D+00  -0.43652D-02   0.67948D-02   0.91152D-02   0.67628D-02
RCS Jet #2    (+X)               98002     0.40755D-01  -0.26385D-01  -0.29882D-01   0.44512D-01  -0.32296D-01  -0.76535D-01
RCS Jet #3    (+Y)               98003     0.44315D-01   0.13343D-02  -0.40250D-01   0.15383D-01   0.44976D-01   0.68706D-01
RCS Jet #4    (-Y)               98004    -0.72927D-02  -0.43979D-02  -0.27449D-01   0.16410D-01  -0.42946D-02   0.48692D-01
RCS Jet #5    (-Y)               98005     0.89454D-01  -0.74309D-01   0.20323D-01   0.40340D-01  -0.25590D-01  -0.57268D-01
RCS Jet #6    (+Y)               98006    -0.25236D-01  -0.68501D-01  -0.51022D-01   0.59351D-01  -0.54498D-01  -0.10669D+00
RCS Jet #7    (+X)               98007     0.31599D+00  -0.41712D+00   0.63206D+00   0.91181D+00   0.88518D+00   0.13577D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.29901D+00   0.18713D+00  -0.25067D+00  -0.34338D+00  -0.34980D+00  -0.60197D+00
Reaction Wheel #2 CG             58042    -0.17426D+00   0.28265D+00  -0.28034D+00   0.41035D+00   0.77712D-01  -0.25942D+00
Reaction Wheel #3 CG             58043    -0.34158D-01   0.11175D+00  -0.68913D-02  -0.57080D-01  -0.86454D-01   0.24010D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.55194D-01   0.10558D+00   0.14863D+00  -0.18901D-01  -0.75985D-03   0.19087D+00
Cryo Cooler Pump                 40101     0.55194D-01   0.10558D+00   0.14863D+00  -0.18901D-01  -0.75985D-03   0.19087D+00
Cryo Cooler Pump                 40101     0.55194D-01   0.10558D+00   0.14863D+00  -0.18901D-01  -0.75985D-03   0.19087D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Second Mirror                    40102     0.52407D-01   0.15936D+00   0.14255D+00  -0.83406D-01  -0.34031D-02   0.18137D+00
Second Mirror                    40102     0.52407D-01   0.15936D+00   0.14255D+00  -0.83406D-01  -0.34031D-02   0.18137D+00
Sensitive Instrument 2           40103    -0.55652D-02  -0.48149D-02  -0.71081D-01  -0.49320D-01   0.50012D-02   0.33866D-01
Sensitive Instrument 2           40103    -0.55652D-02  -0.48149D-02  -0.71081D-01  -0.49320D-01   0.50012D-02   0.33866D-01
Sensitive Instrument 3           40104     0.29676D-01   0.15279D-01  -0.23272D-01  -0.45119D-01   0.92948D-02   0.32852D-01
Sensitive Instrument 4           40105     0.21290D-01   0.19156D-01  -0.35794D-01  -0.45524D-01   0.84834D-02   0.32928D-01
Sensitive Instrument 5           40106     0.20089D-01   0.10591D-01  -0.35249D-01  -0.45524D-01   0.84862D-02   0.32935D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.18522D-01  -0.16171D-01  -0.21236D-01
Accelerometers                   31002     0.18522D-01  -0.16171D-01  -0.21236D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.61093D+00  -0.69057D+00   0.61213D+00   0.91177D+00   0.88514D+00   0.13579D+01

MODE# 39/ 63, Frequency (rad/sec), Damping (zeta), Generalized Mass=    551.93       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

