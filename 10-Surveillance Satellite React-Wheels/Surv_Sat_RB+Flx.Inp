                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.20391D-01   0.12696D+00  -0.74441D-02  -0.78715D-03   0.99016D-02   0.10323D-01
RCS Jet #2    (+X)               98002     0.53332D-01   0.76980D-02  -0.53413D-01   0.57668D-01  -0.64111D-01  -0.13836D+00
RCS Jet #3    (+Y)               98003     0.43266D-01   0.19031D-01  -0.29298D-01   0.10267D-01   0.59293D-01   0.10136D+00
RCS Jet #4    (-Y)               98004    -0.93101D-02   0.12643D-01  -0.46754D-01   0.12380D-01  -0.11149D-01   0.88684D-01
RCS Jet #5    (-Y)               98005     0.14288D+00  -0.78089D-01   0.23717D-01   0.49050D-01  -0.54521D-01  -0.10851D+00
RCS Jet #6    (+Y)               98006    -0.69889D-01  -0.66682D-01  -0.71503D-01   0.83575D-01  -0.10204D+00  -0.20497D+00
RCS Jet #7    (+X)               98007     0.65816D+00  -0.69116D+00   0.13167D+01   0.14750D+01   0.18322D+01   0.22225D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.59820D+00   0.34532D+00  -0.49298D+00  -0.72001D+00  -0.71430D+00  -0.12330D+01
Reaction Wheel #2 CG             58042    -0.26993D+00   0.40567D+00  -0.39062D+00   0.58674D+00   0.63925D-01  -0.45685D+00
Reaction Wheel #3 CG             58043    -0.78717D-01   0.86672D-01  -0.80700D-01  -0.18823D+00  -0.30226D-01   0.29260D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.86037D-01  -0.35076D-01   0.21671D+00  -0.36965D-01   0.35411D-01   0.30450D+00
Cryo Cooler Pump                 40101     0.86037D-01  -0.35076D-01   0.21671D+00  -0.36965D-01   0.35411D-01   0.30450D+00
Cryo Cooler Pump                 40101     0.86037D-01  -0.35076D-01   0.21671D+00  -0.36965D-01   0.35411D-01   0.30450D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Second Mirror                    40102     0.12232D+00   0.92679D-02   0.22064D+00   0.94752D-02   0.35969D-01   0.31242D+00
Second Mirror                    40102     0.12232D+00   0.92679D-02   0.22064D+00   0.94752D-02   0.35969D-01   0.31242D+00
Sensitive Instrument 2           40103    -0.78201D-02   0.47899D-01  -0.12895D+00  -0.10620D+00  -0.54065D-03   0.36991D-01
Sensitive Instrument 2           40103    -0.78201D-02   0.47899D-01  -0.12895D+00  -0.10620D+00  -0.54065D-03   0.36991D-01
Sensitive Instrument 3           40104     0.32569D-01   0.69185D-01  -0.29053D-01  -0.88744D-01   0.10743D-01   0.37842D-01
Sensitive Instrument 4           40105     0.22855D-01   0.73649D-01  -0.52731D-01  -0.89712D-01   0.88006D-02   0.38104D-01
Sensitive Instrument 5           40106     0.21608D-01   0.58488D-01  -0.52165D-01  -0.89717D-01   0.88009D-02   0.38123D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.19291D-01   0.47968D-02  -0.25202D-01
Accelerometers                   31002     0.19291D-01   0.47968D-02  -0.25202D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.12686D+01  -0.11329D+01   0.12754D+01   0.14749D+01   0.18322D+01   0.22228D+01

MODE# 40/ 64, Frequency (rad/sec), Damping (zeta), Generalized Mass=    553.02       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.95211D-01  -0.16260D-01  -0.16792D-01  -0.46332D-03  -0.71477D-02   0.55070D-02
RCS Jet #2    (+X)               98002    -0.76272D-02   0.11451D-01  -0.22990D-01  -0.36025D-02  -0.58102D-02   0.87275D-02
RCS Jet #3    (+Y)               98003    -0.22559D-01  -0.12443D-01   0.19656D-01  -0.17782D-02  -0.13937D-01  -0.24607D-02
RCS Jet #4    (-Y)               98004     0.97164D-02  -0.12079D-01   0.21231D-01  -0.12259D-02  -0.76082D-02  -0.20015D-02
RCS Jet #5    (-Y)               98005    -0.36724D-02   0.20230D-01  -0.21476D-01  -0.17951D-02  -0.40150D-02  -0.20842D-01
RCS Jet #6    (+Y)               98006     0.78730D-02   0.13323D-01  -0.15701D-01  -0.63877D-02  -0.20071D-02   0.35334D-01
RCS Jet #7    (+X)               98007     0.76977D-01  -0.28560D-01   0.49973D-01   0.46973D-01   0.92395D-01   0.80372D-01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.14255D+00   0.23238D-01  -0.99368D-01  -0.86694D-01  -0.14957D+00  -0.14692D+00
Reaction Wheel #2 CG             58042     0.91372D-01  -0.63395D-01   0.74646D-01  -0.12701D+00   0.46393D-02   0.12650D+00
Reaction Wheel #3 CG             58043     0.56183D-01  -0.67322D-02   0.17514D-01   0.42330D-01   0.26310D-01  -0.93295D-01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.35878D-01   0.41005D-02  -0.24333D-01   0.43084D-02  -0.24152D-02  -0.99379D-01
Cryo Cooler Pump                 40101    -0.35878D-01   0.41005D-02  -0.24333D-01   0.43084D-02  -0.24152D-02  -0.99379D-01
Cryo Cooler Pump                 40101    -0.35878D-01   0.41005D-02  -0.24333D-01   0.43084D-02  -0.24152D-02  -0.99379D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Second Mirror                    40102    -0.37093D-01  -0.45397D-03  -0.24643D-01  -0.48727D-03  -0.23756D-02  -0.10064D+00
Second Mirror                    40102    -0.37093D-01  -0.45397D-03  -0.24643D-01  -0.48727D-03  -0.23756D-02  -0.10064D+00
Sensitive Instrument 2           40103    -0.15490D-01  -0.15459D-01   0.10647D-01   0.15956D-01  -0.18888D-01  -0.15859D-01
Sensitive Instrument 2           40103    -0.15490D-01  -0.15459D-01   0.10647D-01   0.15956D-01  -0.18888D-01  -0.15859D-01
Sensitive Instrument 3           40104    -0.31806D-01  -0.22720D-01   0.62660D-02   0.12790D-01  -0.19614D-01  -0.13854D-01
Sensitive Instrument 4           40105    -0.28278D-01  -0.24342D-01   0.11790D-01   0.12884D-01  -0.19344D-01  -0.14041D-01
Sensitive Instrument 5           40106    -0.25539D-01  -0.21614D-01   0.10549D-01   0.12887D-01  -0.19352D-01  -0.14045D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.13688D-01  -0.12621D-01   0.85848D-02
Accelerometers                   31002    -0.13688D-01  -0.12621D-01   0.85848D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.10777D+00  -0.42413D-01   0.47894D-01   0.46970D-01   0.92400D-01   0.80384D-01

MODE# 41/ 66, Frequency (rad/sec), Damping (zeta), Generalized Mass=    569.50       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.40756D-02  -0.14112D+00  -0.17607D-01  -0.22164D-01  -0.26225D-02  -0.14932D-01
RCS Jet #2    (+X)               98002    -0.21356D-01  -0.33864D-01  -0.11069D-01   0.10026D-01   0.53116D-02   0.11733D+00
RCS Jet #3    (+Y)               98003    -0.66432D-01   0.11115D-01   0.29452D-01  -0.21076D-01  -0.58292D-01   0.11667D+00
RCS Jet #4    (-Y)               98004     0.36217D-01   0.30203D-01  -0.35445D-01  -0.48190D-01   0.82420D-01   0.17058D+00
RCS Jet #5    (-Y)               98005    -0.82528D-01   0.38856D-01  -0.34863D-02   0.13284D-01   0.22027D-01   0.58271D-01
RCS Jet #6    (+Y)               98006     0.50886D-01   0.36146D-01  -0.24448D-01   0.13046D-01  -0.94994D-02   0.87989D-01
RCS Jet #7    (+X)               98007     0.84792D+00  -0.10164D+00   0.17782D+01  -0.65185D-01   0.24602D+01   0.12449D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.60780D+00  -0.25467D+00   0.56487D+00   0.79032D+00   0.67381D+00   0.12983D+01
Reaction Wheel #2 CG             58042     0.76576D+00  -0.72903D+00   0.10299D+01  -0.18784D+01   0.33440D-01   0.17348D+01
Reaction Wheel #3 CG             58043     0.31333D-01   0.15091D+01   0.13331D+01   0.84760D+00  -0.27805D+01   0.33806D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.12149D+00  -0.37543D-03  -0.27451D-01   0.95306D-02  -0.23248D-01  -0.23620D+00
Cryo Cooler Pump                 40101    -0.12149D+00  -0.37543D-03  -0.27451D-01   0.95306D-02  -0.23248D-01  -0.23620D+00
Cryo Cooler Pump                 40101    -0.12149D+00  -0.37543D-03  -0.27451D-01   0.95306D-02  -0.23248D-01  -0.23620D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Second Mirror                    40102    -0.14824D+00  -0.15029D-01  -0.27475D-01   0.87893D-02  -0.24426D-01  -0.23596D+00
Second Mirror                    40102    -0.14824D+00  -0.15029D-01  -0.27475D-01   0.87893D-02  -0.24426D-01  -0.23596D+00
Sensitive Instrument 2           40103     0.79557D-01  -0.55098D-02  -0.17422D-01   0.39287D-02   0.62918D-03  -0.56540D-01
Sensitive Instrument 2           40103     0.79557D-01  -0.55098D-02  -0.17422D-01   0.39287D-02   0.62918D-03  -0.56540D-01
Sensitive Instrument 3           40104     0.18963D-01  -0.34233D-01  -0.16925D-01   0.77330D-03  -0.39476D-02  -0.56394D-01
Sensitive Instrument 4           40105     0.33371D-01  -0.40906D-01  -0.16321D-01   0.99228D-03  -0.34774D-02  -0.56465D-01
Sensitive Instrument 5           40106     0.33866D-01  -0.37141D-01  -0.16544D-01   0.99808D-03  -0.34652D-02  -0.56468D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.18985D-01  -0.35680D-01  -0.17765D-01
Accelerometers                   31002     0.18985D-01  -0.35680D-01  -0.17765D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.16676D+01  -0.77106D-01   0.17228D+01  -0.65186D-01   0.24601D+01   0.12449D+00

MODE# 42/ 67, Frequency (rad/sec), Damping (zeta), Generalized Mass=    575.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.82998D-01  -0.15318D+00   0.94450D-01  -0.18082D-01  -0.10065D-01  -0.26250D-02
RCS Jet #2    (+X)               98002    -0.18560D-01  -0.18753D-01   0.12832D+00  -0.45370D-02   0.46276D-01   0.10697D+00
RCS Jet #3    (+Y)               98003     0.27675D-01   0.15783D-01   0.79438D-01  -0.23596D-02  -0.60739D-02  -0.60992D-01
RCS Jet #4    (-Y)               98004    -0.16718D-01   0.39392D-01   0.75286D-01  -0.31974D-01   0.81376D-01   0.79627D-02
RCS Jet #5    (-Y)               98005    -0.78837D-01   0.46696D-01   0.10105D+00   0.35092D-03   0.53306D-01   0.64822D-01
RCS Jet #6    (+Y)               98006     0.44889D-01   0.47728D-01   0.10623D+00  -0.95224D-02   0.44111D-01   0.70211D-01
RCS Jet #7    (+X)               98007     0.16850D+01  -0.11462D+00   0.38511D+01  -0.19008D-01   0.51247D+01   0.16128D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.39539D+00   0.28455D+00  -0.28519D+00  -0.89810D+00  -0.59938D+00  -0.15064D+01
Reaction Wheel #2 CG             58042    -0.55572D-01  -0.22243D+00   0.32645D+00  -0.35324D+00  -0.46670D+00  -0.39608D+00
Reaction Wheel #3 CG             58043    -0.47606D+00  -0.10504D+01  -0.88536D+00  -0.10959D+01   0.15294D+01  -0.11802D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.13109D-01  -0.76057D-02  -0.11719D+00  -0.17444D-01  -0.63827D-01  -0.14041D+00
Cryo Cooler Pump                 40101    -0.13109D-01  -0.76057D-02  -0.11719D+00  -0.17444D-01  -0.63827D-01  -0.14041D+00
Cryo Cooler Pump                 40101    -0.13109D-01  -0.76057D-02  -0.11719D+00  -0.17444D-01  -0.63827D-01  -0.14041D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Second Mirror                    40102    -0.86208D-01   0.82360D-02  -0.11870D+00  -0.19297D-01  -0.62396D-01  -0.13831D+00
Second Mirror                    40102    -0.86208D-01   0.82360D-02  -0.11870D+00  -0.19297D-01  -0.62396D-01  -0.13831D+00
Sensitive Instrument 2           40103     0.28499D-01  -0.90935D-01   0.29969D+00   0.11743D+00   0.35693D-01   0.10821D-02
Sensitive Instrument 2           40103     0.28499D-01  -0.90935D-01   0.29969D+00   0.11743D+00   0.35693D-01   0.10821D-02
Sensitive Instrument 3           40104     0.26295D-01  -0.89949D-01   0.16543D+00   0.93775D-01   0.21124D-01  -0.55847D-02
Sensitive Instrument 4           40105     0.27792D-01  -0.90687D-01   0.18654D+00   0.95603D-01   0.23724D-01  -0.44590D-02
Sensitive Instrument 5           40106     0.24439D-01  -0.76849D-01   0.18806D+00   0.95608D-01   0.23764D-01  -0.44798D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.11359D-01  -0.15862D-01   0.15086D+00
Accelerometers                   31002     0.11359D-01  -0.15862D-01   0.15086D+00

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.33924D+01  -0.10466D+00   0.37357D+01  -0.19012D-01   0.51245D+01   0.16129D+00

MODE# 43/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    593.08       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.12613D+00  -0.22871D+00   0.61817D-01  -0.25938D-01   0.71347D-02  -0.24271D-01
RCS Jet #2    (+X)               98002    -0.15241D-01  -0.12074D+00   0.78065D-01   0.16487D-01   0.30434D-01   0.23156D+00
RCS Jet #3    (+Y)               98003    -0.19946D-01   0.44722D-01   0.23030D-01  -0.11262D-01   0.15310D-01   0.88562D-01
RCS Jet #4    (-Y)               98004    -0.28740D-02   0.63431D-01   0.13527D-02  -0.37360D-01   0.68801D-01   0.14603D+00
RCS Jet #5    (-Y)               98005    -0.17477D+00   0.10280D-01   0.78443D-01   0.23609D-01   0.54797D-01   0.22506D+00
RCS Jet #6    (+Y)               98006     0.14486D+00   0.11204D-01   0.43008D-01   0.22582D-01   0.51726D-02   0.22470D+00
RCS Jet #7    (+X)               98007    -0.21313D+01   0.50662D-02  -0.42881D+01  -0.42931D+00  -0.59350D+01  -0.33864D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.12973D+01   0.65161D+00  -0.11847D+01  -0.23640D+01  -0.18709D+01  -0.38200D+01
Reaction Wheel #2 CG             58042     0.84628D-01  -0.23086D+00   0.29416D+00  -0.47521D+00  -0.25231D+00   0.10854D+00
Reaction Wheel #3 CG             58043    -0.12518D+00   0.51956D+00   0.44552D+00   0.21122D+00  -0.10893D+01   0.14509D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.70930D-01   0.10789D-01  -0.35828D-01   0.39728D-02  -0.57173D-01  -0.16321D+00
Cryo Cooler Pump                 40101    -0.70930D-01   0.10789D-01  -0.35828D-01   0.39728D-02  -0.57173D-01  -0.16321D+00
Cryo Cooler Pump                 40101    -0.70930D-01   0.10789D-01  -0.35828D-01   0.39728D-02  -0.57173D-01  -0.16321D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Second Mirror                    40102    -0.13901D+00   0.37551D-02  -0.36162D-01   0.51554D-02  -0.57451D-01  -0.15930D+00
Second Mirror                    40102    -0.13901D+00   0.37551D-02  -0.36162D-01   0.51554D-02  -0.57451D-01  -0.15930D+00
Sensitive Instrument 2           40103     0.78301D-01  -0.32666D-01   0.13405D+00   0.42572D-01   0.37932D-01  -0.22735D-01
Sensitive Instrument 2           40103     0.78301D-01  -0.32666D-01   0.13405D+00   0.42572D-01   0.37932D-01  -0.22735D-01
Sensitive Instrument 3           40104     0.51958D-01  -0.44459D-01   0.72831D-01   0.32358D-01   0.28508D-01  -0.27809D-01
Sensitive Instrument 4           40105     0.59101D-01  -0.47812D-01   0.77574D-01   0.33366D-01   0.29846D-01  -0.26981D-01
Sensitive Instrument 5           40106     0.54881D-01  -0.41351D-01   0.79489D-01   0.33370D-01   0.29886D-01  -0.26990D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.26476D-01  -0.20908D-01   0.61921D-01
Accelerometers                   31002     0.26476D-01  -0.20908D-01   0.61921D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.41086D+01   0.14058D+00  -0.41544D+01  -0.42930D+00  -0.59347D+01  -0.33871D+00

MODE# 44/ 69, Frequency (rad/sec), Damping (zeta), Generalized Mass=    596.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.21233D-01   0.26477D+00   0.25745D-02   0.32950D-01   0.43993D-02   0.11255D-01
RCS Jet #2    (+X)               98002     0.16072D-01   0.63089D-01   0.64781D-02   0.30318D-01  -0.46859D-02  -0.97942D-01
RCS Jet #3    (+Y)               98003     0.28327D-01  -0.13434D-01  -0.49710D-01   0.34032D-01   0.82753D-01  -0.99191D-01
RCS Jet #4    (-Y)               98004    -0.26368D-01  -0.12163D-01   0.12774D-01   0.22516D-01  -0.52228D-02  -0.96522D-01
RCS Jet #5    (-Y)               98005     0.11004D+00   0.14347D-01   0.30971D-01   0.28865D-01  -0.22423D-03  -0.16711D+00
RCS Jet #6    (+Y)               98006    -0.25895D-01  -0.37380D-02  -0.15845D-01   0.36983D-01  -0.12149D-01  -0.17684D-01
RCS Jet #7    (+X)               98007    -0.11665D+01  -0.36806D+00  -0.24203D+01   0.10208D+01  -0.33101D+01   0.14267D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.15719D+00   0.19975D+00   0.20066D+00  -0.30722D+00   0.31210D+00  -0.54608D+00
Reaction Wheel #2 CG             58042     0.59187D+00  -0.70439D+00   0.94905D+00  -0.17162D+01  -0.35635D+00   0.88570D+00
Reaction Wheel #3 CG             58043    -0.78839D-01  -0.39864D+00  -0.38437D+00  -0.38852D+00   0.87784D+00  -0.93102D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.12456D+00  -0.15394D-01   0.17428D-01  -0.22080D-01   0.78662D-01   0.23080D+00
Cryo Cooler Pump                 40101     0.12456D+00  -0.15394D-01   0.17428D-01  -0.22080D-01   0.78662D-01   0.23080D+00
Cryo Cooler Pump                 40101     0.12456D+00  -0.15394D-01   0.17428D-01  -0.22080D-01   0.78662D-01   0.23080D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Second Mirror                    40102     0.22018D+00   0.14567D-01   0.17097D-01  -0.22918D-01   0.78592D-01   0.21928D+00
Second Mirror                    40102     0.22018D+00   0.14567D-01   0.17097D-01  -0.22918D-01   0.78592D-01   0.21928D+00
Sensitive Instrument 2           40103    -0.39371D-01  -0.44211D-02   0.32259D-01   0.96696D-02   0.77461D-02   0.35473D-01
Sensitive Instrument 2           40103    -0.39371D-01  -0.44211D-02   0.32259D-01   0.96696D-02   0.77461D-02   0.35473D-01
Sensitive Instrument 3           40104    -0.21214D-02   0.13278D-01   0.16538D-01   0.89204D-02   0.86340D-02   0.34036D-01
Sensitive Instrument 4           40105    -0.10803D-01   0.17297D-01   0.17805D-01   0.89608D-02   0.86204D-02   0.34156D-01
Sensitive Instrument 5           40106    -0.12024D-01   0.16375D-01   0.18358D-01   0.89572D-02   0.86179D-02   0.34156D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.86287D-02   0.22313D-01   0.16263D-01
Accelerometers                   31002    -0.86287D-02   0.22313D-01   0.16263D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.22693D+01  -0.67629D+00  -0.23458D+01   0.10207D+01  -0.33100D+01   0.14269D+01

MODE# 45/ 70, Frequency (rad/sec), Damping (zeta), Generalized Mass=    597.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.12185D-01   0.38100D+00  -0.50451D-03   0.42505D-01   0.16576D-01   0.35868D-01
RCS Jet #2    (+X)               98002     0.12546D-01   0.11722D+00  -0.44247D-01   0.29356D-01  -0.36583D-01  -0.19582D+00
RCS Jet #3    (+Y)               98003     0.49758D-02  -0.30441D-01  -0.65084D-01   0.37661D-01   0.69022D-01  -0.10990D+00
RCS Jet #4    (-Y)               98004    -0.41153D-01  -0.45730D-01   0.21909D-01   0.52403D-01  -0.65134D-01  -0.15354D+00
RCS Jet #5    (-Y)               98005     0.19241D+00   0.19912D-01  -0.52441D-02   0.23184D-01  -0.41987D-01  -0.31592D+00
RCS Jet #6    (+Y)               98006    -0.68317D-01  -0.16389D-01  -0.46944D-01   0.37660D-01  -0.35448D-01  -0.28241D-01
RCS Jet #7    (+X)               98007    -0.48049D+00  -0.39655D+00  -0.10943D+01   0.13228D+01  -0.14712D+01   0.17221D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.33890D+00   0.88280D-01   0.39752D+00   0.20860D+00   0.66004D+00   0.31094D+00
Reaction Wheel #2 CG             58042     0.10090D+01  -0.95332D+00   0.13224D+01  -0.25297D+01  -0.12520D+00   0.18760D+01
Reaction Wheel #3 CG             58043     0.47450D-01  -0.67213D+00  -0.62866D+00  -0.44287D+00   0.16184D+01  -0.20017D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.11155D+00  -0.38578D-01   0.12287D-01  -0.35656D-01   0.10692D+00   0.25604D+00
Cryo Cooler Pump                 40101     0.11155D+00  -0.38578D-01   0.12287D-01  -0.35656D-01   0.10692D+00   0.25604D+00
Cryo Cooler Pump                 40101     0.11155D+00  -0.38578D-01   0.12287D-01  -0.35656D-01   0.10692D+00   0.25604D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Second Mirror                    40102     0.24009D+00   0.50534D-02   0.11726D-01  -0.36803D-01   0.10745D+00   0.24718D+00
Second Mirror                    40102     0.24009D+00   0.50534D-02   0.11726D-01  -0.36803D-01   0.10745D+00   0.24718D+00
Sensitive Instrument 2           40103    -0.10060D+00  -0.86645D-02  -0.22284D-01   0.22108D-02  -0.13661D-01   0.36893D-01
Sensitive Instrument 2           40103    -0.10060D+00  -0.86645D-02  -0.22284D-01   0.22108D-02  -0.13661D-01   0.36893D-01
Sensitive Instrument 3           40104    -0.57916D-01   0.11719D-01  -0.18025D-01   0.28160D-02  -0.86111D-02   0.40470D-01
Sensitive Instrument 4           40105    -0.68274D-01   0.16551D-01  -0.16269D-01   0.24392D-02  -0.90560D-02   0.39978D-01
Sensitive Instrument 5           40106    -0.66998D-01   0.14331D-01  -0.16850D-01   0.24362D-02  -0.90899D-02   0.39979D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.46549D-01   0.18806D-01  -0.10538D-01
Accelerometers                   31002    -0.46549D-01   0.18806D-01  -0.10538D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.97063D+00  -0.79883D+00  -0.10611D+01   0.13228D+01  -0.14711D+01   0.17224D+01

MODE# 46/ 71, Frequency (rad/sec), Damping (zeta), Generalized Mass=    602.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.17715D+00   0.66167D-01   0.28753D-01   0.14339D-01   0.16813D-01   0.10174D-01
RCS Jet #2    (+X)               98002    -0.42814D-01   0.82758D-01   0.19739D-01  -0.37321D-01   0.19562D-01  -0.15640D+00
RCS Jet #3    (+Y)               98003    -0.23235D-01  -0.70945D-01  -0.21185D-01  -0.61426D-02  -0.24064D-01  -0.14662D+00
RCS Jet #4    (-Y)               98004    -0.35250D-01  -0.79610D-01  -0.18968D-01   0.30012D-01  -0.10493D+00  -0.16627D+00
RCS Jet #5    (-Y)               98005     0.26125D-01  -0.18944D-01  -0.21654D-01  -0.38743D-01  -0.23894D-02  -0.40799D-01
RCS Jet #6    (+Y)               98006    -0.15905D+00  -0.30484D-02   0.40578D-01  -0.44332D-01   0.41543D-01  -0.17584D+00
RCS Jet #7    (+X)               98007     0.12386D+01   0.21585D+00   0.27587D+01  -0.17077D+00   0.37438D+01  -0.52248D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.59960D+00   0.32587D+00  -0.66020D+00  -0.12658D+01  -0.10051D+01  -0.20556D+01
Reaction Wheel #2 CG             58042     0.41282D-01  -0.63490D+00   0.54831D+00  -0.74473D+00  -0.87942D+00  -0.70652D+00
Reaction Wheel #3 CG             58043     0.32481D+00   0.41827D+00   0.56581D+00   0.10467D+01  -0.52708D+00  -0.30355D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.24668D+00  -0.65076D-02   0.53816D-01  -0.48860D-02   0.24522D+00   0.21584D+00
Cryo Cooler Pump                 40101     0.24668D+00  -0.65076D-02   0.53816D-01  -0.48860D-02   0.24522D+00   0.21584D+00
Cryo Cooler Pump                 40101     0.24668D+00  -0.65076D-02   0.53816D-01  -0.48860D-02   0.24522D+00   0.21584D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Second Mirror                    40102     0.55485D+00   0.11855D-01   0.54096D-01  -0.12233D-01   0.23694D+00   0.14100D+00
Second Mirror                    40102     0.55485D+00   0.11855D-01   0.54096D-01  -0.12233D-01   0.23694D+00   0.14100D+00
Sensitive Instrument 2           40103    -0.38149D-01   0.20430D-01  -0.85629D-01  -0.23668D-01   0.20702D-01   0.22474D-01
Sensitive Instrument 2           40103    -0.38149D-01   0.20430D-01  -0.85629D-01  -0.23668D-01   0.20702D-01   0.22474D-01
Sensitive Instrument 3           40104    -0.10610D-01   0.31263D-01  -0.72483D-01  -0.18090D-01   0.24742D-01   0.24004D-01
Sensitive Instrument 4           40105    -0.16746D-01   0.34136D-01  -0.79922D-01  -0.18703D-01   0.23954D-01   0.23465D-01
Sensitive Instrument 5           40106    -0.20144D-01   0.29979D-01  -0.78385D-01  -0.18707D-01   0.23933D-01   0.23470D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.31577D-01   0.15191D-01  -0.69454D-01
Accelerometers                   31002    -0.31577D-01   0.15191D-01  -0.69454D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.24859D+01   0.26103D+00   0.26744D+01  -0.17076D+00   0.37436D+01  -0.52253D+00

MODE# 47/ 72, Frequency (rad/sec), Damping (zeta), Generalized Mass=    604.05       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.21807D+00  -0.94793D-01  -0.52289D-01  -0.17741D-01  -0.30702D-01  -0.22207D-01
RCS Jet #2    (+X)               98002     0.50574D-02  -0.47107D-01  -0.19775D-01   0.24584D-01  -0.84929D-02   0.12244D+00
RCS Jet #3    (+Y)               98003    -0.26209D-01   0.20201D-01   0.45816D-01   0.11859D-02   0.24668D-02   0.95350D-01
RCS Jet #4    (-Y)               98004     0.29961D-01   0.33726D-01   0.26350D-01  -0.36674D-01   0.79303D-01   0.11947D+00
RCS Jet #5    (-Y)               98005    -0.67962D-01   0.25113D-01   0.68356D-02   0.28469D-01   0.11325D-01   0.87988D-01
RCS Jet #6    (+Y)               98006     0.74356D-01   0.28042D-01  -0.35937D-01   0.27768D-01  -0.26064D-01   0.74448D-01
RCS Jet #7    (+X)               98007    -0.95576D+00  -0.17999D+00  -0.21591D+01   0.12254D+00  -0.29076D+01   0.41134D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.49888D+00  -0.29252D+00   0.52217D+00   0.10209D+01   0.76438D+00   0.16333D+01
Reaction Wheel #2 CG             58042    -0.28630D+00   0.57942D+00  -0.61647D+00   0.10726D+01   0.44226D+00  -0.20599D+00
Reaction Wheel #3 CG             58043    -0.22822D+00  -0.17872D+00  -0.24399D+00  -0.62498D+00   0.10272D-01   0.61360D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.11471D+00   0.93292D-01   0.59334D-01   0.53587D-01   0.73098D-01  -0.31976D+00
Cryo Cooler Pump                 40101     0.11471D+00   0.93292D-01   0.59334D-01   0.53587D-01   0.73098D-01  -0.31976D+00
Cryo Cooler Pump                 40101     0.11471D+00   0.93292D-01   0.59334D-01   0.53587D-01   0.73098D-01  -0.31976D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Second Mirror                    40102     0.22429D+00   0.52381D-01   0.60469D-01   0.46994D-01   0.61708D-01  -0.40495D+00
Second Mirror                    40102     0.22429D+00   0.52381D-01   0.60469D-01   0.46994D-01   0.61708D-01  -0.40495D+00
Sensitive Instrument 2           40103     0.44863D-01  -0.37766D-01   0.83603D-01   0.34493D-01  -0.73787D-02  -0.29437D-01
Sensitive Instrument 2           40103     0.44863D-01  -0.37766D-01   0.83603D-01   0.34493D-01  -0.73787D-02  -0.29437D-01
Sensitive Instrument 3           40104     0.10984D-01  -0.51100D-01   0.56672D-01   0.24462D-01  -0.13897D-01  -0.31007D-01
Sensitive Instrument 4           40105     0.18925D-01  -0.54795D-01   0.64408D-01   0.25199D-01  -0.12798D-01  -0.30624D-01
Sensitive Instrument 5           40106     0.20742D-01  -0.49257D-01   0.63586D-01   0.25206D-01  -0.12778D-01  -0.30632D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.20402D-01  -0.31692D-01   0.53878D-01
Accelerometers                   31002     0.20402D-01  -0.31692D-01   0.53878D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.19244D+01  -0.21159D+00  -0.20936D+01   0.12253D+00  -0.29075D+01   0.41137D+00

MODE# 48/ 73, Frequency (rad/sec), Damping (zeta), Generalized Mass=    615.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.12136D+00  -0.40013D-01   0.28408D-01   0.10409D-01   0.65096D-02   0.44215D-02
RCS Jet #2    (+X)               98002    -0.48065D-01  -0.17921D+00   0.17096D-02   0.12247D-01  -0.22416D-01   0.35366D+00
RCS Jet #3    (+Y)               98003    -0.81080D-01   0.14722D+00  -0.19014D-01  -0.31693D-01  -0.11584D+00   0.26263D+00
RCS Jet #4    (-Y)               98004    -0.17770D-01   0.12609D+00   0.16742D-01   0.12018D-01   0.14717D-01   0.20202D+00
RCS Jet #5    (-Y)               98005    -0.33619D+00   0.10456D-01   0.21630D-01   0.57962D-02  -0.20296D-01   0.46325D+00
RCS Jet #6    (+Y)               98006     0.16346D+00   0.36481D-01   0.10085D-02   0.20104D-01  -0.41742D-01   0.24391D+00
RCS Jet #7    (+X)               98007     0.40826D+00   0.21487D+00   0.95461D+00  -0.74162D+00   0.12738D+01  -0.85915D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.83610D+00  -0.32516D+00  -0.87794D+00   0.10353D+01  -0.14839D+01   0.18331D+01
Reaction Wheel #2 CG             58042     0.10011D+01   0.56226D+00  -0.12173D+00  -0.10867D+01   0.31945D+01   0.56809D+01
Reaction Wheel #3 CG             58043    -0.51972D+00  -0.29975D+00  -0.66030D+00  -0.13055D+01   0.19282D+00   0.98405D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.15422D+00   0.59837D-01  -0.88599D-01   0.68972D-01  -0.83662D-01  -0.41760D+00
Cryo Cooler Pump                 40101    -0.15422D+00   0.59837D-01  -0.88599D-01   0.68972D-01  -0.83662D-01  -0.41760D+00
Cryo Cooler Pump                 40101    -0.15422D+00   0.59837D-01  -0.88599D-01   0.68972D-01  -0.83662D-01  -0.41760D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Second Mirror                    40102    -0.25128D+00  -0.27695D-01  -0.87985D-01   0.66259D-01  -0.88121D-01  -0.42774D+00
Second Mirror                    40102    -0.25128D+00  -0.27695D-01  -0.87985D-01   0.66259D-01  -0.88121D-01  -0.42774D+00
Sensitive Instrument 2           40103     0.80623D-01   0.14191D-01   0.84305D-01   0.35268D-01   0.44614D-01  -0.51550D-01
Sensitive Instrument 2           40103     0.80623D-01   0.14191D-01   0.84305D-01   0.35268D-01   0.44614D-01  -0.51550D-01
Sensitive Instrument 3           40104     0.27694D-01  -0.15067D-01   0.23648D-01   0.31879D-01   0.36088D-01  -0.53405D-01
Sensitive Instrument 4           40105     0.41344D-01  -0.21419D-01   0.27429D-01   0.32590D-01   0.37178D-01  -0.52970D-01
Sensitive Instrument 5           40106     0.36082D-01  -0.13401D-01   0.29815D-01   0.32592D-01   0.37204D-01  -0.52976D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.42132D-02   0.69722D-02   0.18128D-01
Accelerometers                   31002    -0.42132D-02   0.69722D-02   0.18128D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.83262D+00   0.44279D+00   0.92592D+00  -0.74159D+00   0.12737D+01  -0.85930D+00

MODE# 49/ 75, Frequency (rad/sec), Damping (zeta), Generalized Mass=    631.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.13278D-01   0.29319D-01  -0.37514D-02  -0.85608D-02  -0.77479D-02  -0.13452D-01
RCS Jet #2    (+X)               98002    -0.63772D-02   0.59093D-01   0.11673D-01  -0.14947D-01   0.34193D-02  -0.83723D-01
RCS Jet #3    (+Y)               98003    -0.48911D-02  -0.23168D-01   0.80094D-03   0.41588D-02  -0.47740D-02  -0.40968D-01
RCS Jet #4    (-Y)               98004    -0.35432D-02  -0.22458D-01  -0.86478D-03   0.50248D-02   0.41287D-03  -0.42782D-01
RCS Jet #5    (-Y)               98005     0.36730D-01   0.67100D-02  -0.44376D-02  -0.18985D-01  -0.11777D-01  -0.39581D-01
RCS Jet #6    (+Y)               98006    -0.78144D-01   0.17201D-01   0.23040D-01  -0.17376D-01   0.15212D-01  -0.12289D+00
RCS Jet #7    (+X)               98007    -0.66468D-01  -0.84793D-03  -0.96685D-01   0.13193D+00  -0.13790D+00   0.97969D-01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.17594D+00  -0.10723D+00  -0.20994D+00   0.43327D+00  -0.42618D+00   0.69931D+00
Reaction Wheel #2 CG             58042     0.46640D-01   0.83292D-02   0.38540D-01  -0.17860D+00   0.21299D+00   0.42949D+00
Reaction Wheel #3 CG             58043    -0.13661D+00  -0.15939D-01  -0.83854D-01  -0.29803D+00  -0.18953D+00   0.49829D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.64921D-01  -0.53925D-01   0.26120D-01  -0.50102D-01   0.14072D+00   0.30781D+00
Cryo Cooler Pump                 40101     0.64921D-01  -0.53925D-01   0.26120D-01  -0.50102D-01   0.14072D+00   0.30781D+00
Cryo Cooler Pump                 40101     0.64921D-01  -0.53925D-01   0.26120D-01  -0.50102D-01   0.14072D+00   0.30781D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Second Mirror                    40102     0.23107D+00   0.12942D-01   0.25702D-01  -0.54164D-01   0.14221D+00   0.30733D+00
Second Mirror                    40102     0.23107D+00   0.12942D-01   0.25702D-01  -0.54164D-01   0.14221D+00   0.30733D+00
Sensitive Instrument 2           40103     0.17954D-01  -0.19061D-01   0.33325D-01   0.17400D-01   0.19920D-01   0.51137D-02
Sensitive Instrument 2           40103     0.17954D-01  -0.19061D-01   0.33325D-01   0.17400D-01   0.19920D-01   0.51137D-02
Sensitive Instrument 3           40104     0.21782D-01  -0.16044D-01   0.87363D-02   0.11375D-01   0.15770D-01   0.21574D-02
Sensitive Instrument 4           40105     0.21267D-01  -0.15809D-01   0.97210D-02   0.11730D-01   0.16309D-01   0.23339D-02
Sensitive Instrument 5           40106     0.18959D-01  -0.14295D-01   0.10768D-01   0.11731D-01   0.16321D-01   0.23298D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.66951D-02  -0.72280D-02   0.57207D-02
Accelerometers                   31002     0.66951D-02  -0.72280D-02   0.57207D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.11241D+00  -0.42629D-01  -0.93581D-01   0.13193D+00  -0.13790D+00   0.97992D-01

MODE# 50/ 76, Frequency (rad/sec), Damping (zeta), Generalized Mass=    632.95       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.36825D-01   0.11228D+00  -0.86293D-02   0.78869D-02  -0.30568D-01   0.37218D-01
RCS Jet #2    (+X)               98002     0.23330D-02   0.25111D+00   0.31901D-01  -0.76127D-01   0.22903D-01  -0.36214D+00
RCS Jet #3    (+Y)               98003     0.24108D-02  -0.13998D+00   0.28320D-01   0.15208D-01  -0.17464D-02  -0.27131D+00
RCS Jet #4    (-Y)               98004     0.32663D-01  -0.11883D+00  -0.72643D-02  -0.82639D-02   0.35099D-01  -0.19477D+00
RCS Jet #5    (-Y)               98005     0.23303D+00   0.40048D-01  -0.47583D-01  -0.88361D-01  -0.31200D-01  -0.29874D+00
RCS Jet #6    (+Y)               98006    -0.28264D+00   0.60642D-01   0.87334D-01  -0.94123D-01   0.77788D-01  -0.45766D+00
RCS Jet #7    (+X)               98007    -0.41511D+00   0.39020D-01  -0.83221D+00   0.24880D+00  -0.11433D+01   0.49607D-01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.92321D+00  -0.82224D+00  -0.10602D+01   0.28482D+01  -0.22121D+01   0.45404D+01
Reaction Wheel #2 CG             58042    -0.25087D+00  -0.36148D+00   0.23215D+00  -0.14802D+00  -0.92477D+00  -0.12971D+01
Reaction Wheel #3 CG             58043    -0.50487D+00   0.75315D-02  -0.15131D+00  -0.97740D+00  -0.11961D+01   0.24240D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.14584D-01   0.16312D-01  -0.24025D-02   0.20248D-02  -0.71430D-01  -0.10442D+00
Cryo Cooler Pump                 40101    -0.14584D-01   0.16312D-01  -0.24025D-02   0.20248D-02  -0.71430D-01  -0.10442D+00
Cryo Cooler Pump                 40101    -0.14584D-01   0.16312D-01  -0.24025D-02   0.20248D-02  -0.71430D-01  -0.10442D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Second Mirror                    40102    -0.99289D-01   0.12389D-01  -0.26669D-02   0.60408D-02  -0.71382D-01  -0.10164D+00
Second Mirror                    40102    -0.99289D-01   0.12389D-01  -0.26669D-02   0.60408D-02  -0.71382D-01  -0.10164D+00
Sensitive Instrument 2           40103     0.24249D-01  -0.20608D-01   0.60909D-01   0.13793D-01   0.48001D-03   0.11554D-02
Sensitive Instrument 2           40103     0.24249D-01  -0.20608D-01   0.60909D-01   0.13793D-01   0.48001D-03   0.11554D-02
Sensitive Instrument 3           40104     0.22286D-01  -0.19143D-01   0.47340D-01   0.87580D-02  -0.27224D-02  -0.17772D-02
Sensitive Instrument 4           40105     0.22761D-01  -0.19390D-01   0.49833D-01   0.92329D-02  -0.21799D-02  -0.12606D-02
Sensitive Instrument 5           40106     0.23074D-01  -0.18000D-01   0.49693D-01   0.92352D-02  -0.21589D-02  -0.12640D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.22136D-01  -0.78093D-02   0.43186D-01
Accelerometers                   31002     0.22136D-01  -0.78093D-02   0.43186D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.79598D+00  -0.42807D-01  -0.80646D+00   0.24878D+00  -0.11432D+01   0.49640D-01

MODE# 51/ 77, Frequency (rad/sec), Damping (zeta), Generalized Mass=    635.94       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.86533D-01  -0.22196D-01  -0.14273D-01  -0.97165D-02  -0.18804D-01   0.17681D-01
RCS Jet #2    (+X)               98002    -0.11806D-01   0.92195D-01   0.27117D-02  -0.39340D-01  -0.24083D-01  -0.10917D+00
RCS Jet #3    (+Y)               98003     0.14619D-02   0.15762D-01   0.27767D-01   0.10723D-02  -0.27373D-01  -0.59653D-01
RCS Jet #4    (-Y)               98004    -0.42815D-01   0.19446D-01   0.14825D-01   0.24097D-02  -0.26191D-01  -0.60508D-01
RCS Jet #5    (-Y)               98005     0.28988D-01   0.19494D-01  -0.20320D-01  -0.52470D-01  -0.56652D-01  -0.89393D-02
RCS Jet #6    (+Y)               98006    -0.12850D+00   0.46709D-01   0.47678D-01  -0.39632D-01  -0.67702D-02  -0.22865D+00
RCS Jet #7    (+X)               98007    -0.20634D+00   0.40762D-01  -0.44762D+00  -0.15652D-01  -0.61574D+00  -0.11037D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.27005D+00  -0.27016D+00  -0.30632D+00   0.10083D+01  -0.70338D+00   0.16457D+01
Reaction Wheel #2 CG             58042    -0.20183D+00  -0.24615D+00   0.22205D+00  -0.58880D-01  -0.10529D+01  -0.14836D+01
Reaction Wheel #3 CG             58043    -0.12969D+00  -0.25760D-01  -0.64328D-01  -0.26388D+00  -0.17452D+00   0.42307D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.40730D+00  -0.34120D+00   0.86842D-01  -0.30064D+00   0.77863D+00   0.16166D+01
Cryo Cooler Pump                 40101     0.40730D+00  -0.34120D+00   0.86842D-01  -0.30064D+00   0.77863D+00   0.16166D+01
Cryo Cooler Pump                 40101     0.40730D+00  -0.34120D+00   0.86842D-01  -0.30064D+00   0.77863D+00   0.16166D+01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Second Mirror                    40102     0.13303D+01   0.35366D-02   0.82462D-01  -0.29623D+00   0.78583D+00   0.16032D+01
Second Mirror                    40102     0.13303D+01   0.35366D-02   0.82462D-01  -0.29623D+00   0.78583D+00   0.16032D+01
Sensitive Instrument 2           40103     0.21519D-01   0.73857D-02   0.74730D-01   0.27086D-01   0.57953D-01   0.28172D-01
Sensitive Instrument 2           40103     0.21519D-01   0.73857D-02   0.74730D-01   0.27086D-01   0.57953D-01   0.28172D-01
Sensitive Instrument 3           40104     0.49170D-01   0.18158D-01   0.15113D-01   0.23945D-01   0.52300D-01   0.21283D-01
Sensitive Instrument 4           40105     0.43790D-01   0.20626D-01   0.15042D-01   0.24437D-01   0.52921D-01   0.21816D-01
Sensitive Instrument 5           40106     0.36298D-01   0.22689D-01   0.18438D-01   0.24431D-01   0.52945D-01   0.21814D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.28140D-02   0.27789D-01   0.74573D-02
Accelerometers                   31002     0.28140D-02   0.27789D-01   0.74573D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.41148D+00   0.43499D-01  -0.43376D+00  -0.15649D-01  -0.61574D+00  -0.11038D+00

MODE# 52/ 78, Frequency (rad/sec), Damping (zeta), Generalized Mass=    647.55       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.11365D+00   0.31255D-01   0.11667D-01   0.22644D-01  -0.97147D-02   0.26232D-02
RCS Jet #2    (+X)               98002     0.23907D-01  -0.29067D+00  -0.11688D-01   0.67200D-01  -0.74219D-02   0.34794D+00
RCS Jet #3    (+Y)               98003     0.94390D-01   0.17240D+00  -0.47417D-01   0.10467D-01  -0.49013D-02   0.21436D+00
RCS Jet #4    (-Y)               98004    -0.46366D-01   0.17112D+00   0.31553D-01   0.13186D-01   0.17032D-02   0.21872D+00
RCS Jet #5    (-Y)               98005    -0.21692D+00  -0.92275D-01   0.47202D-01   0.73027D-01   0.26578D-01   0.33842D+00
RCS Jet #6    (+Y)               98006     0.25538D+00  -0.89585D-01  -0.62714D-01   0.74444D-01  -0.43121D-01   0.31260D+00
RCS Jet #7    (+X)               98007    -0.49429D-01   0.45862D-01  -0.20942D+00  -0.49610D+00  -0.28682D+00  -0.40390D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.40271D+00  -0.42379D+00  -0.43750D+00   0.15864D+01  -0.91822D+00   0.26130D+01
Reaction Wheel #2 CG             58042    -0.27776D+00  -0.58305D+00   0.48753D+00  -0.49346D-01  -0.27420D+01  -0.36932D+01
Reaction Wheel #3 CG             58043     0.46940D+00  -0.38360D-01   0.17478D+00   0.13168D+01   0.14047D+01  -0.29887D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.18112D+00   0.24736D+00  -0.10875D+00   0.22266D+00  -0.58728D+00  -0.98983D+00
Cryo Cooler Pump                 40101    -0.18112D+00   0.24736D+00  -0.10875D+00   0.22266D+00  -0.58728D+00  -0.98983D+00
Cryo Cooler Pump                 40101    -0.18112D+00   0.24736D+00  -0.10875D+00   0.22266D+00  -0.58728D+00  -0.98983D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Second Mirror                    40102    -0.87865D+00  -0.13338D-01  -0.10604D+00   0.21884D+00  -0.59000D+00  -0.97292D+00
Second Mirror                    40102    -0.87865D+00  -0.13338D-01  -0.10604D+00   0.21884D+00  -0.59000D+00  -0.97292D+00
Sensitive Instrument 2           40103    -0.70679D-01   0.24427D-02   0.19725D-01   0.65849D-02  -0.19583D-01   0.37828D-01
Sensitive Instrument 2           40103    -0.70679D-01   0.24427D-02   0.19725D-01   0.65849D-02  -0.19583D-01   0.37828D-01
Sensitive Instrument 3           40104    -0.30568D-01   0.21366D-01   0.19264D-01   0.82416D-02  -0.15373D-01   0.38671D-01
Sensitive Instrument 4           40105    -0.40462D-01   0.25955D-01   0.23217D-01   0.80747D-02  -0.15661D-01   0.38603D-01
Sensitive Instrument 5           40106    -0.38247D-01   0.24622D-01   0.22212D-01   0.80693D-02  -0.15679D-01   0.38605D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.13296D-01   0.31586D-01   0.22162D-01
Accelerometers                   31002    -0.13296D-01   0.31586D-01   0.22162D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.14497D+00   0.20218D+00  -0.20295D+00  -0.49609D+00  -0.28676D+00  -0.40399D+00

MODE# 53/ 79, Frequency (rad/sec), Damping (zeta), Generalized Mass=    651.44       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.12818D+00   0.11644D+00  -0.53760D-01   0.26735D-01  -0.24542D-03   0.49483D-01
RCS Jet #2    (+X)               98002     0.27181D-01  -0.14668D+00  -0.20004D-01   0.22202D-01   0.23984D-01   0.14674D+00
RCS Jet #3    (+Y)               98003     0.78520D-01   0.70486D-01  -0.57816D-01   0.23533D-01   0.24334D-01   0.69418D-01
RCS Jet #4    (-Y)               98004    -0.25248D-02   0.84343D-01  -0.30678D-02   0.74230D-02   0.22451D-03   0.11631D+00
RCS Jet #5    (-Y)               98005    -0.88955D-01  -0.67786D-01  -0.13208D-01   0.30761D-01   0.38113D-01   0.18419D+00
RCS Jet #6    (+Y)               98006     0.13266D+00  -0.63555D-01  -0.48459D-01   0.17483D-01   0.21228D-01   0.15290D+00
RCS Jet #7    (+X)               98007     0.30718D+00   0.10378D+00   0.61150D+00  -0.28280D+00   0.88810D+00  -0.37115D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.33210D+00   0.34662D+00   0.24154D+00  -0.10340D+01   0.55445D+00  -0.15550D+01
Reaction Wheel #2 CG             58042    -0.17203D+00  -0.46449D+00   0.46155D+00  -0.40241D+00  -0.21199D+01  -0.26290D+01
Reaction Wheel #3 CG             58043    -0.12926D+01  -0.20353D+00  -0.10532D+01  -0.34560D+01  -0.15606D+01   0.52278D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101    -0.66404D-01   0.95282D-01  -0.86432D-01   0.10210D+00  -0.34435D+00  -0.51967D+00
Cryo Cooler Pump                 40101    -0.66404D-01   0.95282D-01  -0.86432D-01   0.10210D+00  -0.34435D+00  -0.51967D+00
Cryo Cooler Pump                 40101    -0.66404D-01   0.95282D-01  -0.86432D-01   0.10210D+00  -0.34435D+00  -0.51967D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Second Mirror                    40102    -0.47527D+00  -0.34533D-01  -0.85425D-01   0.10268D+00  -0.34494D+00  -0.50808D+00
Second Mirror                    40102    -0.47527D+00  -0.34533D-01  -0.85425D-01   0.10268D+00  -0.34494D+00  -0.50808D+00
Sensitive Instrument 2           40103    -0.28917D-01   0.73333D-02  -0.61974D-01  -0.71504D-02  -0.23470D-01   0.29002D-01
Sensitive Instrument 2           40103    -0.28917D-01   0.73333D-02  -0.61974D-01  -0.71504D-02  -0.23470D-01   0.29002D-01
Sensitive Instrument 3           40104    -0.22141D-02   0.20771D-01  -0.38865D-01  -0.61284D-02  -0.21109D-01   0.27714D-01
Sensitive Instrument 4           40105    -0.92618D-02   0.24075D-01  -0.37862D-01  -0.65453D-02  -0.21518D-01   0.27188D-01
Sensitive Instrument 5           40106    -0.62158D-02   0.21403D-01  -0.39242D-01  -0.65494D-02  -0.21530D-01   0.27192D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.14410D-01   0.18922D-01  -0.34252D-01
Accelerometers                   31002     0.14410D-01   0.18922D-01  -0.34252D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.60305D+00   0.18972D+00   0.59149D+00  -0.28279D+00   0.88801D+00  -0.37121D+00

MODE# 54/ 82, Frequency (rad/sec), Damping (zeta), Generalized Mass=    662.07       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.18725D+00  -0.46696D-01  -0.28952D-01   0.19027D-01   0.52244D-01  -0.74125D-01
RCS Jet #2    (+X)               98002    -0.66646D-01  -0.17238D+00   0.70147D-01   0.43618D-01   0.80501D-01   0.42454D+00
RCS Jet #3    (+Y)               98003    -0.34018D-01   0.12400D+00  -0.59515D-01   0.40922D-02  -0.11416D-01   0.16610D+00
RCS Jet #4    (-Y)               98004     0.69938D-01   0.15454D+00  -0.42706D-02  -0.21404D-01   0.92731D-02   0.24943D+00
RCS Jet #5    (-Y)               98005    -0.55491D+00  -0.22913D-02   0.66920D-01   0.60569D-01   0.11612D+00   0.97884D+00
RCS Jet #6    (+Y)               98006     0.40617D-01   0.13765D+00  -0.14147D-01   0.46022D-01   0.31654D-01  -0.12919D+00
RCS Jet #7    (+X)               98007    -0.65693D-01  -0.26336D-01   0.13071D+00  -0.21316D+00   0.22225D+00  -0.68207D-02

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.91368D-01  -0.69757D-01  -0.34757D+00   0.19010D+00  -0.72778D+00   0.40271D+00
Reaction Wheel #2 CG             58042    -0.18213D-01  -0.15418D+00   0.24802D+00  -0.48200D+00  -0.47274D+00  -0.11048D+00
Reaction Wheel #3 CG             58043     0.35541D-01  -0.51050D-02   0.76130D-01   0.70841D+00   0.60930D+00  -0.14303D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.23263D-01  -0.18011D+00  -0.11850D+00  -0.96451D-01   0.15316D+00   0.24422D+00
Cryo Cooler Pump                 40101     0.23263D-01  -0.18011D+00  -0.11850D+00  -0.96451D-01   0.15316D+00   0.24422D+00
Cryo Cooler Pump                 40101     0.23263D-01  -0.18011D+00  -0.11850D+00  -0.96451D-01   0.15316D+00   0.24422D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Second Mirror                    40102     0.20292D+00  -0.11652D+00  -0.11675D+00  -0.72901D-01   0.15421D+00   0.24719D+00
Second Mirror                    40102     0.20292D+00  -0.11652D+00  -0.11675D+00  -0.72901D-01   0.15421D+00   0.24719D+00
Sensitive Instrument 2           40103     0.28511D+00   0.54712D-01   0.94014D-01   0.32579D-01   0.11086D+00  -0.50422D-01
Sensitive Instrument 2           40103     0.28511D+00   0.54712D-01   0.94014D-01   0.32579D-01   0.11086D+00  -0.50422D-01
Sensitive Instrument 3           40104     0.21330D+00   0.16352D-01   0.66864D-02   0.27184D-01   0.86222D-01  -0.72904D-01
Sensitive Instrument 4           40105     0.23213D+00   0.75433D-02   0.34309D-02   0.28772D-01   0.88439D-01  -0.71237D-01
Sensitive Instrument 5           40106     0.21963D+00   0.16193D-01   0.91070D-02   0.28770D-01   0.88571D-01  -0.71242D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.11721D+00   0.28458D-01  -0.19285D-01
Accelerometers                   31002     0.11721D+00   0.28458D-01  -0.19285D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.83451D-02   0.44571D-01   0.12568D+00  -0.21314D+00   0.22214D+00  -0.68452D-02

MODE# 55/ 83, Frequency (rad/sec), Damping (zeta), Generalized Mass=    665.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.35337D-01   0.15436D+00  -0.19836D-02   0.25993D-01   0.17176D-01  -0.21371D-01
RCS Jet #2    (+X)               98002    -0.21179D-01  -0.14299D+00   0.35237D-01   0.65126D-01   0.43604D-01   0.24607D+00
RCS Jet #3    (+Y)               98003    -0.26569D-01  -0.90687D-02  -0.22410D-01   0.90335D-03   0.27289D-01   0.59069D-01
RCS Jet #4    (-Y)               98004     0.48690D-01   0.10253D-02   0.26814D-02  -0.11436D-01  -0.12212D-01   0.75434D-01
RCS Jet #5    (-Y)               98005    -0.25904D+00  -0.31032D-01   0.70274D-01   0.83375D-01   0.92576D-01   0.44155D+00
RCS Jet #6    (+Y)               98006     0.88983D-01   0.16127D-01  -0.45147D-01   0.71240D-01  -0.42379D-02   0.69797D-01
RCS Jet #7    (+X)               98007     0.25727D-01  -0.92915D-01   0.16436D+00   0.88624D-01   0.23032D+00   0.30967D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.49421D-01  -0.84158D-01  -0.14134D+00   0.11851D+00  -0.28183D+00   0.16892D+00
Reaction Wheel #2 CG             58042    -0.10721D-01  -0.44467D-01  -0.21745D-01   0.26269D-01   0.36082D-01   0.11072D+00
Reaction Wheel #3 CG             58043    -0.11128D-01  -0.15780D-01   0.72556D-01   0.27852D+00   0.87679D-02  -0.21806D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.15850D-01   0.25237D+00   0.17079D+00   0.10720D+00   0.20159D+00   0.39383D+00
Cryo Cooler Pump                 40101     0.15850D-01   0.25237D+00   0.17079D+00   0.10720D+00   0.20159D+00   0.39383D+00
Cryo Cooler Pump                 40101     0.15850D-01   0.25237D+00   0.17079D+00   0.10720D+00   0.20159D+00   0.39383D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Second Mirror                    40102     0.25282D+00   0.25194D+00   0.15890D+00   0.14246D-01   0.19594D+00   0.37039D+00
Second Mirror                    40102     0.25282D+00   0.25194D+00   0.15890D+00   0.14246D-01   0.19594D+00   0.37039D+00
Sensitive Instrument 2           40103     0.10846D+00   0.41911D-01  -0.54791D-01  -0.41915D-01   0.24943D-01  -0.22950D-01
Sensitive Instrument 2           40103     0.10846D+00   0.41911D-01  -0.54791D-01  -0.41915D-01   0.24943D-01  -0.22950D-01
Sensitive Instrument 3           40104     0.79149D-01   0.25547D-01  -0.27911D-01  -0.32171D-01   0.23532D-01  -0.28195D-01
Sensitive Instrument 4           40105     0.86376D-01   0.22158D-01  -0.38773D-01  -0.32348D-01   0.23026D-01  -0.27710D-01
Sensitive Instrument 5           40106     0.83122D-01   0.19350D-01  -0.37295D-01  -0.32348D-01   0.23068D-01  -0.27702D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.49855D-01  -0.11085D-01  -0.35258D-01
Accelerometers                   31002     0.49855D-01  -0.11085D-01  -0.35258D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.10245D+00  -0.11550D+00   0.15916D+00   0.88615D-01   0.23028D+00   0.30971D+00

MODE# 56/ 84, Frequency (rad/sec), Damping (zeta), Generalized Mass=    669.00       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.14780D-01   0.19039D+00  -0.10924D-01   0.48634D-01  -0.13301D-01  -0.12320D+00
RCS Jet #2    (+X)               98002    -0.24249D-01  -0.74479D-01  -0.81676D-01   0.10903D+00  -0.65113D-01   0.36134D+00
RCS Jet #3    (+Y)               98003    -0.19980D+00   0.27855D-01  -0.97116D-02  -0.15815D-01   0.91804D-03   0.14502D+00
RCS Jet #4    (-Y)               98004     0.74037D-01   0.13193D-01   0.53743D-01   0.92305D-02  -0.10764D+00   0.10947D+00
RCS Jet #5    (-Y)               98005    -0.23716D+00   0.13946D+00   0.49981D-01   0.12271D+00   0.15370D-01   0.25231D+00
RCS Jet #6    (+Y)               98006     0.26033D+00   0.11149D+00  -0.14380D+00   0.13640D+00  -0.14956D+00   0.46337D+00
RCS Jet #7    (+X)               98007     0.27487D+00  -0.37902D+00   0.34949D+00   0.85782D+00   0.50090D+00   0.15277D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.62088D-01  -0.68273D-01   0.11445D+00   0.23947D+00   0.29758D+00   0.34694D+00
Reaction Wheel #2 CG             58042     0.17631D-01  -0.16090D+00   0.41201D-01   0.18136D+00  -0.74941D+00  -0.11004D+01
Reaction Wheel #3 CG             58043    -0.21647D+00  -0.57430D-01  -0.23716D+00  -0.83893D+00  -0.40412D+00   0.13417D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.35456D-01  -0.13262D+00   0.13998D+00  -0.11439D+00   0.69890D+00   0.86214D+00
Cryo Cooler Pump                 40101     0.35456D-01  -0.13262D+00   0.13998D+00  -0.11439D+00   0.69890D+00   0.86214D+00
Cryo Cooler Pump                 40101     0.35456D-01  -0.13262D+00   0.13998D+00  -0.11439D+00   0.69890D+00   0.86214D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Second Mirror                    40102     0.86556D+00   0.18640D-01   0.14183D+00  -0.11960D+00   0.69752D+00   0.83360D+00
Second Mirror                    40102     0.86556D+00   0.18640D-01   0.14183D+00  -0.11960D+00   0.69752D+00   0.83360D+00
Sensitive Instrument 2           40103     0.88428D-01   0.10655D+00  -0.74923D-01  -0.46684D-01  -0.21199D-01  -0.11819D+00
Sensitive Instrument 2           40103     0.88428D-01   0.10655D+00  -0.74923D-01  -0.46684D-01  -0.21199D-01  -0.11819D+00
Sensitive Instrument 3           40104    -0.27771D-01   0.39916D-01  -0.32459D-01  -0.21712D-01  -0.16373D-01  -0.10748D+00
Sensitive Instrument 4           40105    -0.45193D-03   0.27233D-01  -0.35929D-01  -0.22364D-01  -0.17312D-01  -0.10768D+00
Sensitive Instrument 5           40106     0.19991D-02   0.30971D-01  -0.37040D-01  -0.22364D-01  -0.17320D-01  -0.10767D+00

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.12954D-01   0.60362D-02  -0.27761D-01
Accelerometers                   31002    -0.12954D-01   0.60362D-02  -0.27761D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.44175D+00  -0.63066D+00   0.33822D+00   0.85778D+00   0.50092D+00   0.15280D+01

MODE# 57/ 87, Frequency (rad/sec), Damping (zeta), Generalized Mass=    679.93       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.11845D+00  -0.53646D-01  -0.10233D+00  -0.65765D-02  -0.12020D+00   0.16886D-01
RCS Jet #2    (+X)               98002    -0.22678D-01  -0.35702D-01   0.59367D-01  -0.22422D-01   0.79037D-01  -0.13008D-01
RCS Jet #3    (+Y)               98003     0.72340D-01   0.28821D-01  -0.51358D-01   0.13902D-01  -0.28844D-02   0.19044D-02
RCS Jet #4    (-Y)               98004    -0.50224D-02   0.53976D-01  -0.58066D-01  -0.12043D-01   0.31027D-01   0.67650D-01
RCS Jet #5    (-Y)               98005    -0.86495D-01  -0.68529D-01  -0.19687D-02  -0.16877D-01   0.65774D-01   0.19704D+00
RCS Jet #6    (+Y)               98006    -0.98348D-01  -0.16257D-01   0.37086D-01  -0.35263D-01   0.96779D-01  -0.21031D+00
RCS Jet #7    (+X)               98007    -0.11687D+00   0.13180D+00  -0.22293D+00  -0.34968D+00  -0.27950D+00  -0.54173D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.21946D+00   0.79866D-01   0.41030D-01  -0.26808D+00   0.18310D-01  -0.37136D+00
Reaction Wheel #2 CG             58042     0.55246D-01  -0.17642D+00   0.26610D+00  -0.60137D+00  -0.15926D+00   0.28750D+00
Reaction Wheel #3 CG             58043     0.18165D+00   0.16266D+00   0.25102D+00   0.88132D+00   0.29231D+00  -0.11833D+01

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.65668D-02  -0.42527D-01  -0.14261D+00  -0.25096D-02  -0.24272D+00  -0.26162D+00
Cryo Cooler Pump                 40101     0.65668D-02  -0.42527D-01  -0.14261D+00  -0.25096D-02  -0.24272D+00  -0.26162D+00
Cryo Cooler Pump                 40101     0.65668D-02  -0.42527D-01  -0.14261D+00  -0.25096D-02  -0.24272D+00  -0.26162D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Second Mirror                    40102    -0.28224D+00  -0.67270D-01  -0.14602D+00  -0.36128D-02  -0.24227D+00  -0.25145D+00
Second Mirror                    40102    -0.28224D+00  -0.67270D-01  -0.14602D+00  -0.36128D-02  -0.24227D+00  -0.25145D+00
Sensitive Instrument 2           40103     0.67315D-01  -0.37554D-02  -0.57086D-01   0.75494D-02   0.48318D-01   0.35778D-01
Sensitive Instrument 2           40103     0.67315D-01  -0.37554D-02  -0.57086D-01   0.75494D-02   0.48318D-01   0.35778D-01
Sensitive Instrument 3           40104     0.93186D-01   0.10290D-01  -0.75477D-01  -0.84754D-03   0.38922D-01   0.22862D-01
Sensitive Instrument 4           40105     0.87508D-01   0.12959D-01  -0.80239D-01  -0.71644D-03   0.39430D-01   0.22631D-01
Sensitive Instrument 5           40106     0.81930D-01   0.11406D-01  -0.77708D-01  -0.71975D-03   0.39464D-01   0.22630D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.48085D-01   0.12056D-01  -0.82126D-01
Accelerometers                   31002     0.48085D-01   0.12056D-01  -0.82126D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.20997D+00   0.23620D+00  -0.21664D+00  -0.34967D+00  -0.27953D+00  -0.54180D+00

MODE# 58/ 89, Frequency (rad/sec), Damping (zeta), Generalized Mass=    693.45       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001    -0.65016D-01   0.12186D+00   0.57537D-01  -0.18329D-01   0.19247D-01  -0.69566D-01
RCS Jet #2    (+X)               98002     0.25647D-01   0.77644D-01   0.63720D-01  -0.52498D-01   0.54988D-01  -0.29688D+00
RCS Jet #3    (+Y)               98003     0.72367D-01  -0.17515D+00   0.72116D-01  -0.18025D-01   0.24824D-01  -0.22243D+00
RCS Jet #4    (-Y)               98004     0.19335D-02  -0.16511D+00  -0.59921D-01  -0.37212D-01   0.58273D-01  -0.19457D+00
RCS Jet #5    (-Y)               98005     0.28514D+00  -0.72932D-01  -0.60851D-02  -0.47299D-01   0.40684D-01  -0.44352D+00
RCS Jet #6    (+Y)               98006    -0.12476D+00  -0.11103D+00   0.79374D-01  -0.68456D-01   0.90617D-01  -0.12944D+00
RCS Jet #7    (+X)               98007    -0.77621D-01   0.16965D+00  -0.32072D-02  -0.51230D+00  -0.63430D-01  -0.84798D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.17633D-01  -0.58856D-01   0.24744D-01  -0.42241D+00   0.29959D-01  -0.77390D+00
Reaction Wheel #2 CG             58042    -0.94558D-02  -0.54903D-01  -0.18676D+00   0.35369D+00   0.91870D+00   0.88490D+00
Reaction Wheel #3 CG             58043    -0.82915D-02  -0.11362D+00   0.18321D+00   0.28886D+00  -0.56150D+00   0.49388D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.19452D-01   0.24738D+00   0.23053D+00   0.15983D+00  -0.15858D+00  -0.97832D-01
Cryo Cooler Pump                 40101     0.19452D-01   0.24738D+00   0.23053D+00   0.15983D+00  -0.15858D+00  -0.97832D-01
Cryo Cooler Pump                 40101     0.19452D-01   0.24738D+00   0.23053D+00   0.15983D+00  -0.15858D+00  -0.97832D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Second Mirror                    40102    -0.17213D+00   0.10321D+00   0.23847D+00   0.16961D+00  -0.15785D+00  -0.83555D-01
Second Mirror                    40102    -0.17213D+00   0.10321D+00   0.23847D+00   0.16961D+00  -0.15785D+00  -0.83555D-01
Sensitive Instrument 2           40103    -0.10636D+00   0.46671D-01  -0.21872D+00  -0.13891D+00  -0.68645D-01   0.43232D-01
Sensitive Instrument 2           40103    -0.10636D+00   0.46671D-01  -0.21872D+00  -0.13891D+00  -0.68645D-01   0.43232D-01
Sensitive Instrument 3           40104    -0.51745D-01   0.69204D-01  -0.58912D-01  -0.10358D+00  -0.38254D-01   0.55499D-01
Sensitive Instrument 4           40105    -0.66110D-01   0.75849D-01  -0.80424D-01  -0.10616D+00  -0.42707D-01   0.54868D-01
Sensitive Instrument 5           40106    -0.60072D-01   0.57276D-01  -0.83164D-01  -0.10617D+00  -0.42769D-01   0.54902D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.13191D-01  -0.16073D-01  -0.47963D-01
Accelerometers                   31002    -0.13191D-01  -0.16073D-01  -0.47963D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.98773D-01   0.32139D+00  -0.17696D-02  -0.51229D+00  -0.63400D-01  -0.84810D+00

MODE# 59/ 94, Frequency (rad/sec), Damping (zeta), Generalized Mass=    729.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.26162D-01   0.48044D+00   0.10319D-01   0.14416D+00   0.12499D-01   0.50182D-01
RCS Jet #2    (+X)               98002     0.20759D-01  -0.33091D-01   0.84723D-01   0.79680D-01   0.14716D+00  -0.16930D+00
RCS Jet #3    (+Y)               98003     0.93455D-01  -0.28546D+00   0.13171D-01   0.36481D-01   0.65848D-01  -0.30636D+00
RCS Jet #4    (-Y)               98004     0.96631D-01  -0.25043D+00  -0.77910D-02  -0.18467D-01   0.59899D-01  -0.21628D+00
RCS Jet #5    (-Y)               98005     0.12722D+00  -0.14172D+00   0.78305D-01   0.12019D+00   0.20378D+00  -0.11942D+00
RCS Jet #6    (+Y)               98006    -0.95276D-01  -0.13411D+00  -0.51876D-01   0.58885D-01   0.13756D+00  -0.15376D+00
RCS Jet #7    (+X)               98007    -0.10749D+00  -0.66238D-01  -0.20514D+00   0.80884D+00  -0.25874D+00   0.79090D+00

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.44048D-01  -0.78217D-01  -0.16594D-01   0.11303D+00  -0.11640D+00  -0.34904D-01
Reaction Wheel #2 CG             58042    -0.38055D-01  -0.10421D+00  -0.10417D+00   0.21180D+00   0.53237D+00   0.51970D+00
Reaction Wheel #3 CG             58043    -0.48141D-01  -0.13303D+00   0.11141D+00   0.25849D+00  -0.41036D+00   0.29218D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.22055D-01   0.85123D+00   0.55782D+00   0.57832D+00  -0.80916D-01   0.12746D+00
Cryo Cooler Pump                 40101     0.22055D-01   0.85123D+00   0.55782D+00   0.57832D+00  -0.80916D-01   0.12746D+00
Cryo Cooler Pump                 40101     0.22055D-01   0.85123D+00   0.55782D+00   0.57832D+00  -0.80916D-01   0.12746D+00

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Second Mirror                    40102    -0.84202D-01   0.37462D+00   0.58086D+00   0.55104D+00  -0.82793D-01   0.14618D+00
Second Mirror                    40102    -0.84202D-01   0.37462D+00   0.58086D+00   0.55104D+00  -0.82793D-01   0.14618D+00
Sensitive Instrument 2           40103    -0.10326D+00   0.10261D+00  -0.44129D+00  -0.25775D+00  -0.14594D+00   0.39481D-01
Sensitive Instrument 2           40103    -0.10326D+00   0.10261D+00  -0.44129D+00  -0.25775D+00  -0.14594D+00   0.39481D-01
Sensitive Instrument 3           40104    -0.51081D-01   0.11758D+00  -0.13173D+00  -0.18754D+00  -0.91387D-01   0.60026D-01
Sensitive Instrument 4           40105    -0.66730D-01   0.12483D+00  -0.16799D+00  -0.19258D+00  -0.99854D-01   0.58618D-01
Sensitive Instrument 5           40106    -0.52603D-01   0.93759D-01  -0.17440D+00  -0.19258D+00  -0.99946D-01   0.58685D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.27051D-01  -0.41755D-01  -0.10841D+00
Accelerometers                   31002     0.27051D-01  -0.41755D-01  -0.10841D+00

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.19366D+00  -0.31811D+00  -0.19930D+00   0.80881D+00  -0.25868D+00   0.79105D+00

MODE# 60/ 95, Frequency (rad/sec), Damping (zeta), Generalized Mass=    740.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
RCS Jet #1    (+X)               98001     0.35959D-01   0.28256D+00  -0.10725D-01   0.41546D-01   0.57240D-02   0.15120D-01
RCS Jet #2    (+X)               98002     0.89610D-03  -0.29061D-01   0.27685D-01   0.80617D-01   0.77184D-01  -0.28494D-01
RCS Jet #3    (+Y)               98003     0.46756D-01  -0.10690D+00  -0.23578D-01   0.40200D-01   0.75886D-01  -0.11727D+00
RCS Jet #4    (-Y)               98004     0.46677D-01  -0.85016D-01   0.27199D-01   0.10546D-01  -0.28846D-01  -0.51748D-01
RCS Jet #5    (-Y)               98005    -0.57787D-02  -0.61323D-01   0.57778D-01   0.10965D+00   0.12716D+00   0.59734D-01
RCS Jet #6    (+Y)               98006    -0.30158D-01  -0.45443D-01  -0.76508D-01   0.75504D-01   0.52528D-01  -0.53203D-01
RCS Jet #7    (+X)               98007    -0.32138D-01  -0.12351D+00  -0.12644D+00   0.96364D+00  -0.13267D+00   0.10840D+01

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.38234D-01   0.54279D-02  -0.12327D-01   0.15698D+00  -0.54276D-01   0.16211D+00
Reaction Wheel #2 CG             58042     0.23872D-02  -0.32136D-01   0.14296D-01  -0.73282D-01   0.71947D-01   0.14665D+00
Reaction Wheel #3 CG             58043    -0.41638D-01  -0.34842D-01  -0.32082D-01  -0.92395D-01  -0.95136D-01   0.15960D+00

                              Node ID#     Modal Data at the  3 External Torque Points...
Cryo Cooler Pump                 40101     0.27854D-01   0.27903D+00   0.18476D+00   0.18584D+00  -0.40835D-01   0.44672D-01
Cryo Cooler Pump                 40101     0.27854D-01   0.27903D+00   0.18476D+00   0.18584D+00  -0.40835D-01   0.44672D-01
Cryo Cooler Pump                 40101     0.27854D-01   0.27903D+00   0.18476D+00   0.18584D+00  -0.40835D-01   0.44672D-01

                              Node ID#     Modal Data at the 13 Gyros ...
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Second Mirror                    40102    -0.22816D-01   0.13193D+00   0.19216D+00   0.17636D+00  -0.40523D-01   0.51331D-01
Second Mirror                    40102    -0.22816D-01   0.13193D+00   0.19216D+00   0.17636D+00  -0.40523D-01   0.51331D-01
Sensitive Instrument 2           40103    -0.69981D-01   0.84027D-02  -0.16241D+00  -0.79921D-01  -0.75637D-01   0.20849D-01
Sensitive Instrument 2           40103    -0.69981D-01   0.84027D-02  -0.16241D+00  -0.79921D-01  -0.75637D-01   0.20849D-01
Sensitive Instrument 3           40104    -0.43498D-01   0.20726D-01  -0.45681D-01  -0.61583D-01  -0.55313D-01   0.30511D-01
Sensitive Instrument 4           40105    -0.51402D-01   0.24421D-01  -0.54644D-01  -0.63424D-01  -0.58200D-01   0.29567D-01
Sensitive Instrument 5           40106    -0.43168D-01   0.13531D-01  -0.58378D-01  -0.63422D-01  -0.58252D-01   0.29587D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.54855D-02  -0.25231D-01  -0.31773D-01
Accelerometers                   31002     0.54855D-02  -0.25231D-01  -0.31773D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.76304D-01  -0.42040D+00  -0.12345D+00   0.96360D+00  -0.13264D+00   0.10842D+01
---------------------------------------------------------------------------------------------------------------------------------------------
                     S to Z TRANSFORMATIONS
---------------------------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
Space Surveill Satellite with RCS and Reaction Wheels (Rigid-Body, Z-Transf)
! Transform the Rigid vehicle model to Discrete using the 
! S to Z Transformation method and  0.01 sec Sampling Period
!
Space Surveillance Satellite with RCS and Reaction Wheels (Rigid-Body)
From S-plane to Z-plane using the Z-Transform, dT= 0.01
----------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
Space Surveill Satellite with RCS and Reaction Wheels (Gimbals, No Flex, Z-Transf)
! Transform the Rigid vehicle model with Gimbals to Discrete using the 
! S to Z Transformation method and  0.01 sec Sampling Period
!
Space Surveillance Satellite with RCS and Reaction Wheels (Gimbals, No Flex)
From S-plane to Z-plane using the Z-Transform, dT= 0.01
----------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
Space Surveill Satellite with RCS and Reaction Wheels (Gimbals, 60 Modes, Z-Transf)
! Transform the Flex vehicle model with Gimbals to Discrete using the 
! S to Z Transformation method and  0.01 sec Sampling Period
!
Space Surveillance Satellite with RCS and Reaction Wheels (Gimbals & 60 Flex Modes)
From S-plane to Z-plane using the Z-Transform, dT= 0.01
---------------------------------------------------------------------------------------------------------------------------------------------
                       MATLAB CONVERSIONS
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Space Surveill Satellite with RCS and Reaction Wheels (Rigid-Body, Z-Transf)                                
System                                                                                          
fv_rb.m                                                                         
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Space Surveill Satellite with RCS and Reaction Wheels (Gimbals, No Flex, Z-Transf)                                
System                                                                                          
fv_grb.m                                                                         
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Space Surveill Satellite with RCS and Reaction Wheels (Gimbals, 60 Modes, Z-Transf)                                
System                                                                                          
fv_60.m                                                                         
---------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END
