Inertial Attitude Sensors            6    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Second Mirror                        9     0.26637D-01   0.58007D-02   0.16580D+00   0.63967D-01   0.67585D-01  -0.50909D-01
Second Mirror                        9     0.26637D-01   0.58007D-02   0.16580D+00   0.63967D-01   0.67585D-01  -0.50909D-01
Sensitive Instrument 2              10    -0.12177D+00   0.10587D+00  -0.17709D+00  -0.10026D+00  -0.56873D-01  -0.16532D-01
Sensitive Instrument 2              10    -0.12177D+00   0.10587D+00  -0.17709D+00  -0.10026D+00  -0.56873D-01  -0.16532D-01
Sensitive Instrument 3              11    -0.13134D+00   0.99905D-01  -0.58609D-01  -0.77429D-01  -0.41087D-01  -0.54137D-02
Sensitive Instrument 4              12    -0.13011D+00   0.99336D-01  -0.73287D-01  -0.78749D-01  -0.43194D-01  -0.59492D-02
Sensitive Instrument 5              13    -0.12400D+00   0.88555D-01  -0.76059D-01  -0.78754D-01  -0.43243D-01  -0.59328D-02

MODE# 51/ 51, Frequency (rad/sec), Damping (zeta), Generalized Mass=    507.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.21425D+00   0.53510D-01  -0.30535D-01  -0.60580D-02  -0.36260D-02  -0.38951D-01
RCS Jet #2    (+X)                  22     0.30280D-01   0.13589D-01  -0.10842D+00   0.87521D-02  -0.59977D-01  -0.97350D-01
RCS Jet #3    (+Y)                  23     0.46402D-01  -0.26995D-01   0.47608D-01  -0.32375D-02  -0.15008D-01  -0.75602D-01
RCS Jet #4    (-Y)                  24    -0.35570D-01  -0.41767D-01   0.39138D-01   0.11151D-01  -0.61884D-01  -0.11815D+00
RCS Jet #5    (-Y)                  25     0.13777D+00  -0.28616D-01  -0.66689D-01   0.93812D-02  -0.53658D-01  -0.20879D+00
RCS Jet #6    (+Y)                  26     0.97955D-02  -0.61142D-01  -0.82201D-01   0.12850D-01  -0.61684D-01   0.45235D-01
RCS Jet #7    (+X)                  27     0.30152D+00  -0.21120D+00   0.17465D+00   0.44531D+00   0.31446D+00   0.62705D+00
RCS Jet #8    (+X)                  28     0.40633D+00  -0.34556D+00   0.16759D+00   0.44530D+00   0.31451D+00   0.62713D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.39319D+00   0.14336D-01  -0.20239D+00  -0.12653D+00  -0.24775D+00  -0.23113D+00
Reaction Wheel #2 Spin Axis         18     0.23301D+00  -0.14963D+00   0.10164D+00  -0.14528D+00  -0.10751D-02   0.10687D+00
Reaction Wheel #3 Spin Axis         19     0.24433D+00  -0.81430D-01   0.33745D-02   0.77710D-01   0.10694D+00  -0.29569D+00
Cryo Cooler Pump                     8     0.63099D-01   0.18958D-01   0.57811D-01   0.12464D-01   0.92506D-02   0.51625D-01
Cryo Cooler Pump                     8     0.63099D-01   0.18958D-01   0.57811D-01   0.12464D-01   0.92506D-02   0.51625D-01
Cryo Cooler Pump                     8     0.63099D-01   0.18958D-01   0.57811D-01   0.12464D-01   0.92506D-02   0.51625D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.68290D-01   0.18743D-01  -0.21586D-02  -0.24012D-01  -0.65689D-01   0.39990D-01
Accelerometers                       7    -0.68290D-01   0.18743D-01  -0.21586D-02  -0.24012D-01  -0.65689D-01   0.39990D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors            6    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors            6    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors            6    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors            6    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors            6    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Second Mirror                        9     0.75368D-01   0.98239D-02   0.58468D-01   0.97973D-02   0.10424D-01   0.50682D-01
Second Mirror                        9     0.75368D-01   0.98239D-02   0.58468D-01   0.97973D-02   0.10424D-01   0.50682D-01
Sensitive Instrument 2              10    -0.16885D+00   0.10905D-01  -0.75370D-01  -0.29442D-01  -0.70170D-01   0.39246D-01
Sensitive Instrument 2              10    -0.16885D+00   0.10905D-01  -0.75370D-01  -0.29442D-01  -0.70170D-01   0.39246D-01
Sensitive Instrument 3              11    -0.12511D+00   0.34219D-01  -0.12949D-01  -0.22580D-01  -0.59906D-01   0.46328D-01
Sensitive Instrument 4              12    -0.13700D+00   0.39760D-01  -0.11560D-01  -0.23296D-01  -0.60936D-01   0.45769D-01
Sensitive Instrument 5              13    -0.12838D+00   0.33521D-01  -0.15470D-01  -0.23298D-01  -0.60980D-01   0.45775D-01

MODE# 52/ 52, Frequency (rad/sec), Damping (zeta), Generalized Mass=    527.33       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.12748D+00  -0.88146D-03   0.87665D-01  -0.12014D-02   0.21907D-01  -0.59827D-01
RCS Jet #2    (+X)                  22     0.66565D-01  -0.18575D+00   0.92117D-01   0.29711D-01   0.36502D-01   0.20063D+00
RCS Jet #3    (+Y)                  23     0.16868D+00   0.76755D-01  -0.49709D-01   0.29362D-01   0.87150D-01  -0.78994D-01
RCS Jet #4    (-Y)                  24    -0.64983D-01   0.81131D-01   0.44395D-01   0.19214D-01   0.20942D-01  -0.63684D-01
RCS Jet #5    (-Y)                  25    -0.31373D-01  -0.56650D-01   0.96518D-01   0.36419D-01   0.51013D-01   0.76829D-01
RCS Jet #6    (+Y)                  26     0.32905D+00  -0.11462D+00   0.46102D-01   0.36523D-01   0.30371D-01   0.55122D+00
RCS Jet #7    (+X)                  27     0.96566D-01   0.15700D+01   0.38156D+00  -0.28754D+01   0.41726D+00  -0.44861D+01
RCS Jet #8    (+X)                  28     0.23557D+00   0.24278D+01   0.37216D+00  -0.28753D+01   0.41724D+00  -0.44868D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.11700D+00  -0.25441D+00   0.19707D+00   0.36895D+00   0.16560D+00   0.76315D+00
Reaction Wheel #2 Spin Axis         18    -0.23014D+00   0.12143D+00  -0.15256D+00   0.45455D+00  -0.37398D-02  -0.49409D+00
Reaction Wheel #3 Spin Axis         19     0.91005D-02   0.10700D+00   0.18097D+00   0.21644D+00  -0.20442D+00   0.19722D+00
Cryo Cooler Pump                     8     0.17570D+00  -0.24797D-01  -0.92631D-01  -0.22306D-01  -0.63324D-01   0.23106D+00
Cryo Cooler Pump                     8     0.17570D+00  -0.24797D-01  -0.92631D-01  -0.22306D-01  -0.63324D-01   0.23106D+00
Cryo Cooler Pump                     8     0.17570D+00  -0.24797D-01  -0.92631D-01  -0.22306D-01  -0.63324D-01   0.23106D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.10272D-01   0.49654D-01   0.72915D-01   0.61992D-01   0.17909D-01   0.84431D-01
Accelerometers                       7     0.10272D-01   0.49654D-01   0.72915D-01   0.61992D-01   0.17909D-01   0.84431D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors            6     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors            6     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors            6     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors            6     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors            6     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Second Mirror                        9     0.99320D-01  -0.49797D-02  -0.93608D-01  -0.18569D-01  -0.60931D-01   0.23539D+00
Second Mirror                        9     0.99320D-01  -0.49797D-02  -0.93608D-01  -0.18569D-01  -0.60931D-01   0.23539D+00
Sensitive Instrument 2              10    -0.66383D-01  -0.38261D-01   0.15700D+00   0.60874D-01   0.25934D-01   0.90211D-01
Sensitive Instrument 2              10    -0.66383D-01  -0.38261D-01   0.15700D+00   0.60874D-01   0.25934D-01   0.90211D-01
Sensitive Instrument 3              11     0.25626D-01   0.57953D-02   0.80614D-01   0.52213D-01   0.22644D-01   0.84090D-01
Sensitive Instrument 4              12     0.42279D-02   0.15702D-01   0.91199D-01   0.52792D-01   0.23387D-01   0.84580D-01
Sensitive Instrument 5              13     0.91704D-03   0.17757D-01   0.92700D-01   0.52786D-01   0.23399D-01   0.84574D-01

MODE# 53/ 53, Frequency (rad/sec), Damping (zeta), Generalized Mass=    528.70       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.76208D-01   0.45136D-02  -0.17904D-01  -0.40328D-02  -0.19967D-02  -0.46373D-02
RCS Jet #2    (+X)                  22     0.10951D-01   0.28825D-01  -0.47109D-01  -0.43097D-02  -0.24222D-01  -0.75383D-01
RCS Jet #3    (+Y)                  23     0.92827D-02  -0.18422D-01   0.22574D-01  -0.70604D-02  -0.20126D-01  -0.13050D-01
RCS Jet #4    (-Y)                  24     0.19813D-05  -0.24692D-01  -0.31831D-02  -0.15295D-02  -0.22230D-01  -0.31925D-01
RCS Jet #5    (-Y)                  25     0.70858D-01  -0.11632D-01  -0.36848D-01  -0.54535D-02  -0.25444D-01  -0.95254D-01
RCS Jet #6    (+Y)                  26    -0.48009D-01  -0.12765D-01  -0.29818D-01  -0.46438D-02  -0.22810D-01  -0.91120D-01
RCS Jet #7    (+X)                  27     0.82511D-01  -0.20400D+00   0.82820D-02   0.38321D+00   0.47356D-01   0.57242D+00
RCS Jet #8    (+X)                  28     0.98304D-01  -0.31888D+00   0.72201D-02   0.38320D+00   0.47376D-01   0.57250D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.19111D+00   0.55682D-01  -0.13444D+00  -0.14112D+00  -0.13598D+00  -0.26743D+00
Reaction Wheel #2 Spin Axis         18     0.13304D+00  -0.54415D-01   0.32510D-01  -0.10548D+00   0.59788D-01   0.19007D+00
Reaction Wheel #3 Spin Axis         19     0.68355D-01  -0.13589D+00  -0.11901D+00  -0.94688D-01   0.21595D+00  -0.26729D+00
Cryo Cooler Pump                     8     0.10811D-01   0.88134D-02   0.39629D-01   0.57456D-02   0.45274D-02   0.14898D-01
Cryo Cooler Pump                     8     0.10811D-01   0.88134D-02   0.39629D-01   0.57456D-02   0.45274D-02   0.14898D-01
Cryo Cooler Pump                     8     0.10811D-01   0.88134D-02   0.39629D-01   0.57456D-02   0.45274D-02   0.14898D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.16530D-01   0.18347D-02  -0.18813D-01  -0.22900D-01  -0.22770D-01   0.71002D-02
Accelerometers                       7    -0.16530D-01   0.18347D-02  -0.18813D-01  -0.22900D-01  -0.22770D-01   0.71002D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors            6    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors            6    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors            6    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors            6    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors            6    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Second Mirror                        9     0.16262D-01   0.47275D-02   0.39943D-01   0.45536D-02   0.46186D-02   0.14536D-01
Second Mirror                        9     0.16262D-01   0.47275D-02   0.39943D-01   0.45536D-02   0.46186D-02   0.14536D-01
Sensitive Instrument 2              10    -0.44747D-01   0.13077D-01  -0.62141D-01  -0.25914D-01  -0.26342D-01   0.71851D-02
Sensitive Instrument 2              10    -0.44747D-01   0.13077D-01  -0.62141D-01  -0.25914D-01  -0.26342D-01   0.71851D-02
Sensitive Instrument 3              11    -0.36201D-01   0.18111D-01  -0.23439D-01  -0.21269D-01  -0.21664D-01   0.10108D-01
Sensitive Instrument 4              12    -0.38811D-01   0.19333D-01  -0.26251D-01  -0.21680D-01  -0.22265D-01   0.98347D-02
Sensitive Instrument 5              13    -0.35660D-01   0.15629D-01  -0.27679D-01  -0.21682D-01  -0.22282D-01   0.98388D-02

MODE# 54/ 54, Frequency (rad/sec), Damping (zeta), Generalized Mass=    529.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.14907D+00  -0.17507D+00   0.63848D-01  -0.41099D-01   0.35218D-01   0.19141D-01
RCS Jet #2    (+X)                  22     0.78346D-01  -0.53442D-01   0.49202D-01  -0.23108D-01   0.15416D-01  -0.95896D-01
RCS Jet #3    (+Y)                  23     0.17387D+00   0.54206D-01  -0.23151D-01  -0.14518D-01  -0.15274D-01   0.65820D-01
RCS Jet #4    (-Y)                  24    -0.85349D-02   0.43690D-01  -0.76539D-01  -0.51398D-02   0.54094D-01   0.28775D-01
RCS Jet #5    (-Y)                  25     0.12850D+00  -0.11202D+00   0.19306D-01  -0.28225D-01  -0.35118D-02  -0.49562D-01
RCS Jet #6    (+Y)                  26    -0.53684D-01  -0.84024D-01   0.61979D-01  -0.31456D-01   0.29208D-01  -0.28380D+00
RCS Jet #7    (+X)                  27    -0.16280D+00   0.25331D+00  -0.23647D+00  -0.63120D+00  -0.38650D+00  -0.96049D+00
RCS Jet #8    (+X)                  28    -0.29160D+00   0.44215D+00  -0.22776D+00  -0.63118D+00  -0.38648D+00  -0.96064D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.14271D+00   0.58751D-01   0.96402D-01  -0.32836D-01   0.22984D+00  -0.95474D-01
Reaction Wheel #2 Spin Axis         18     0.26706D+00  -0.85114D-01   0.13707D+00  -0.42978D+00   0.20239D+00   0.71258D+00
Reaction Wheel #3 Spin Axis         19    -0.74476D-01   0.12387D-02  -0.11397D+00  -0.20274D+00   0.63749D-01   0.15776D+00
Cryo Cooler Pump                     8     0.15809D+00  -0.74437D-01  -0.23936D-01  -0.63948D-01  -0.67182D-01   0.28302D+00
Cryo Cooler Pump                     8     0.15809D+00  -0.74437D-01  -0.23936D-01  -0.63948D-01  -0.67182D-01   0.28302D+00
Cryo Cooler Pump                     8     0.15809D+00  -0.74437D-01  -0.23936D-01  -0.63948D-01  -0.67182D-01   0.28302D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.71504D-01  -0.32426D-03  -0.30268D-01  -0.53785D-02   0.42336D-01   0.62041D-01
Accelerometers                       7     0.71504D-01  -0.32426D-03  -0.30268D-01  -0.53785D-02   0.42336D-01   0.62041D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors            6     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors            6     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors            6     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors            6     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors            6     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Second Mirror                        9     0.74322D-01  -0.10273D-01  -0.25624D-01  -0.54464D-01  -0.66010D-01   0.28885D+00
Second Mirror                        9     0.74322D-01  -0.10273D-01  -0.25624D-01  -0.54464D-01  -0.66010D-01   0.28885D+00
Sensitive Instrument 2              10     0.34277D-01  -0.40486D-01  -0.64295D-02   0.17352D-02   0.42283D-01   0.75678D-01
Sensitive Instrument 2              10     0.34277D-01  -0.40486D-01  -0.64295D-02   0.17352D-02   0.42283D-01   0.75678D-01
Sensitive Instrument 3              11     0.10788D+00  -0.13983D-02  -0.22600D-01  -0.55756D-02   0.38233D-01   0.66732D-01
Sensitive Instrument 4              12     0.90957D-01   0.64500D-02  -0.28523D-01  -0.53776D-02   0.38471D-01   0.66968D-01
Sensitive Instrument 5              13     0.85513D-01   0.13913D-02  -0.26054D-01  -0.53792D-02   0.38498D-01   0.66967D-01

MODE# 55/ 55, Frequency (rad/sec), Damping (zeta), Generalized Mass=    531.85       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.23150D-01   0.23657D-01  -0.95909D-02   0.28187D-02  -0.48562D-02  -0.46126D-02
RCS Jet #2    (+X)                  22    -0.11351D-01   0.95403D-02  -0.86422D-02   0.36415D-02  -0.28474D-02   0.86074D-02
RCS Jet #3    (+Y)                  23    -0.25514D-01  -0.84770D-02   0.33532D-02   0.23068D-02   0.44172D-03  -0.41309D-02
RCS Jet #4    (-Y)                  24     0.19857D-02  -0.71815D-02   0.10811D-01   0.12060D-02  -0.80279D-02   0.12046D-03
RCS Jet #5    (-Y)                  25    -0.15198D-01   0.14946D-01  -0.38557D-02   0.42710D-02  -0.53174D-03   0.26975D-02
RCS Jet #6    (+Y)                  26     0.15931D-02   0.11839D-01  -0.10191D-01   0.45871D-02  -0.44603D-02   0.28711D-01
RCS Jet #7    (+X)                  27     0.24459D-01  -0.75665D-01   0.31364D-01   0.16584D+00   0.53303D-01   0.25418D+00
RCS Jet #8    (+X)                  28     0.42222D-01  -0.12524D+00   0.30164D-01   0.16583D+00   0.53302D-01   0.25422D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.25752D-01   0.17244D-02  -0.19202D-01  -0.66707D-02  -0.37595D-01  -0.91780D-02
Reaction Wheel #2 Spin Axis         18    -0.30990D-01   0.16345D-01  -0.18878D-01   0.52902D-01  -0.23237D-01  -0.82356D-01
Reaction Wheel #3 Spin Axis         19     0.12017D-01   0.81227D-02   0.18010D-01   0.27469D-01  -0.13663D-01  -0.14314D-01
Cryo Cooler Pump                     8    -0.23722D-01   0.54578D-02  -0.95785D-03   0.48660D-02   0.98294D-02  -0.43522D-01
Cryo Cooler Pump                     8    -0.23722D-01   0.54578D-02  -0.95785D-03   0.48660D-02   0.98294D-02  -0.43522D-01
Cryo Cooler Pump                     8    -0.23722D-01   0.54578D-02  -0.95785D-03   0.48660D-02   0.98294D-02  -0.43522D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.97641D-02  -0.41320D-02   0.37253D-02   0.21312D-02  -0.60840D-02  -0.96410D-02
Accelerometers                       7    -0.97641D-02  -0.41320D-02   0.37253D-02   0.21312D-02  -0.60840D-02  -0.96410D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.14458D-01   0.77726D-02  -0.24783D-02  -0.57134D-03  -0.48314D-02  -0.95402D-02
Inertial Attitude Sensors            6    -0.14458D-01   0.77726D-02  -0.24783D-02  -0.57134D-03  -0.48314D-02  -0.95402D-02
Inertial Attitude Sensors            6    -0.14458D-01   0.77726D-02  -0.24783D-02  -0.57134D-03  -0.48314D-02  -0.95402D-02
Inertial Attitude Sensors            6    -0.14458D-01   0.77726D-02  -0.24783D-02  -0.57134D-03  -0.48314D-02  -0.95402D-02
Inertial Attitude Sensors            6    -0.14458D-01   0.77726D-02  -0.24783D-02  -0.57134D-03  -0.48314D-02  -0.95402D-02
Inertial Attitude Sensors            6    -0.14458D-01   0.77726D-02  -0.24783D-02  -0.57134D-03  -0.48314D-02  -0.95402D-02
Second Mirror                        9    -0.11398D-01   0.75774D-03  -0.82334D-03   0.39020D-02   0.97008D-02  -0.44340D-01
Second Mirror                        9    -0.11398D-01   0.75774D-03  -0.82334D-03   0.39020D-02   0.97008D-02  -0.44340D-01
Sensitive Instrument 2              10    -0.37450D-02  -0.18463D-03   0.25312D-02   0.26792D-02  -0.57899D-02  -0.11443D-01
Sensitive Instrument 2              10    -0.37450D-02  -0.18463D-03   0.25312D-02   0.26792D-02  -0.57899D-02  -0.11443D-01
Sensitive Instrument 3              11    -0.15038D-01  -0.58727D-02   0.25978D-02   0.26722D-02  -0.56724D-02  -0.10255D-01
Sensitive Instrument 4              12    -0.12432D-01  -0.70789D-02   0.39360D-02   0.26780D-02  -0.56366D-02  -0.10307D-01
Sensitive Instrument 5              13    -0.11634D-01  -0.60379D-02   0.35742D-02   0.26789D-02  -0.56404D-02  -0.10307D-01

MODE# 56/ 56, Frequency (rad/sec), Damping (zeta), Generalized Mass=    532.81       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.57901D-01   0.49622D-01  -0.15434D-01   0.13777D-01  -0.63708D-03   0.22318D-02
RCS Jet #2    (+X)                  22    -0.75590D-02   0.26921D-01  -0.44558D-01   0.24793D-02  -0.25606D-01  -0.34387D-01
RCS Jet #3    (+Y)                  23    -0.32222D-01  -0.21065D-01   0.20074D-01  -0.56399D-02  -0.75916D-02  -0.11806D-01
RCS Jet #4    (-Y)                  24    -0.44821D-03  -0.26010D-01   0.72578D-02   0.94493D-03  -0.32017D-01  -0.24047D-01
RCS Jet #5    (-Y)                  25     0.25006D-01   0.97828D-02  -0.27811D-01   0.16528D-02  -0.22189D-01  -0.57644D-01
RCS Jet #6    (+Y)                  26    -0.23738D-01   0.34054D-02  -0.33476D-01   0.58133D-02  -0.30319D-01  -0.94362D-02
RCS Jet #7    (+X)                  27     0.10095D+00  -0.14481D+00   0.74110D-01   0.29514D+00   0.13537D+00   0.44293D+00
RCS Jet #8    (+X)                  28     0.14607D+00  -0.23324D+00   0.71066D-01   0.29513D+00   0.13538D+00   0.44300D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.15928D+00   0.24303D-01  -0.11175D+00  -0.96634D-01  -0.14352D+00  -0.17304D+00
Reaction Wheel #2 Spin Axis         18     0.59459D-01  -0.59696D-01   0.35534D-01  -0.51686D-01  -0.30883D-01  -0.23496D-02
Reaction Wheel #3 Spin Axis         19     0.63431D-01  -0.69198D-01  -0.35169D-01  -0.37193D-03   0.93866D-01  -0.17038D+00
Cryo Cooler Pump                     8    -0.27164D-01   0.34017D-01   0.59855D-01   0.23399D-01   0.19183D-01  -0.33680D-01
Cryo Cooler Pump                     8    -0.27164D-01   0.34017D-01   0.59855D-01   0.23399D-01   0.19183D-01  -0.33680D-01
Cryo Cooler Pump                     8    -0.27164D-01   0.34017D-01   0.59855D-01   0.23399D-01   0.19183D-01  -0.33680D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.27850D-01   0.58257D-02  -0.11570D-01  -0.26909D-01  -0.22678D-01  -0.73952D-02
Accelerometers                       7    -0.27850D-01   0.58257D-02  -0.11570D-01  -0.26909D-01  -0.22678D-01  -0.73952D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.29567D-01   0.17685D-01  -0.15598D-01  -0.37879D-01  -0.17308D-01  -0.64244D-02
Inertial Attitude Sensors            6    -0.29567D-01   0.17685D-01  -0.15598D-01  -0.37879D-01  -0.17308D-01  -0.64244D-02
Inertial Attitude Sensors            6    -0.29567D-01   0.17685D-01  -0.15598D-01  -0.37879D-01  -0.17308D-01  -0.64244D-02
Inertial Attitude Sensors            6    -0.29567D-01   0.17685D-01  -0.15598D-01  -0.37879D-01  -0.17308D-01  -0.64244D-02
Inertial Attitude Sensors            6    -0.29567D-01   0.17685D-01  -0.15598D-01  -0.37879D-01  -0.17308D-01  -0.64244D-02
Inertial Attitude Sensors            6    -0.29567D-01   0.17685D-01  -0.15598D-01  -0.37879D-01  -0.17308D-01  -0.64244D-02
Second Mirror                        9    -0.40570D-02   0.12973D-01   0.60616D-01   0.19657D-01   0.18721D-01  -0.35159D-01
Second Mirror                        9    -0.40570D-02   0.12973D-01   0.60616D-01   0.19657D-01   0.18721D-01  -0.35159D-01
Sensitive Instrument 2              10    -0.39927D-01   0.31484D-01  -0.60824D-01  -0.33710D-01  -0.27258D-01  -0.99941D-02
Sensitive Instrument 2              10    -0.39927D-01   0.31484D-01  -0.60824D-01  -0.33710D-01  -0.27258D-01  -0.99941D-02
Sensitive Instrument 3              11    -0.47753D-01   0.27274D-01  -0.16868D-01  -0.25626D-01  -0.21359D-01  -0.54874D-02
Sensitive Instrument 4              12    -0.46411D-01   0.26654D-01  -0.20810D-01  -0.26111D-01  -0.22122D-01  -0.57098D-02
Sensitive Instrument 5              13    -0.43281D-01   0.23319D-01  -0.22230D-01  -0.26112D-01  -0.22141D-01  -0.57042D-02

MODE# 57/ 57, Frequency (rad/sec), Damping (zeta), Generalized Mass=    534.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.13013D+00  -0.10972D+00   0.48007D-01  -0.12695D-01   0.23096D-01   0.12168D-01
RCS Jet #2    (+X)                  22     0.62065D-01  -0.71250D-01   0.55599D-01  -0.14048D-01   0.24406D-01  -0.21140D-01
RCS Jet #3    (+Y)                  23     0.14185D+00   0.47078D-01  -0.26637D-01  -0.97759D-02   0.18670D-01   0.26712D-01
RCS Jet #4    (-Y)                  24    -0.90224D-02   0.43420D-01  -0.64409D-01  -0.85879D-02   0.43630D-01   0.12928D-01
RCS Jet #5    (-Y)                  25     0.64746D-01  -0.86699D-01   0.29965D-01  -0.15484D-01   0.16788D-01   0.12546D-01
RCS Jet #6    (+Y)                  26     0.16859D-01  -0.71890D-01   0.53800D-01  -0.18078D-01   0.29369D-01  -0.10951D+00
RCS Jet #7    (+X)                  27    -0.14462D+00   0.51048D+00  -0.15784D+00  -0.11055D+01  -0.27317D+00  -0.16792D+01
RCS Jet #8    (+X)                  28    -0.23565D+00   0.84128D+00  -0.15170D+00  -0.11054D+01  -0.27317D+00  -0.16794D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.17030D+00  -0.41911D-01   0.12204D+00   0.77632D-01   0.21800D+00   0.13601D+00
Reaction Wheel #2 Spin Axis         18     0.11708D+00  -0.71139D-01   0.69864D-01  -0.21745D+00   0.11478D+00   0.36103D+00
Reaction Wheel #3 Spin Axis         19    -0.98536D-01  -0.76529D-01  -0.12309D+00  -0.17459D+00   0.97049D-01   0.77645D-01
Cryo Cooler Pump                     8     0.13478D+00  -0.33748D-01   0.53858D-02  -0.29089D-01  -0.54017D-01   0.24846D+00
Cryo Cooler Pump                     8     0.13478D+00  -0.33748D-01   0.53858D-02  -0.29089D-01  -0.54017D-01   0.24846D+00
Cryo Cooler Pump                     8     0.13478D+00  -0.33748D-01   0.53858D-02  -0.29089D-01  -0.54017D-01   0.24846D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.58854D-01   0.21551D-01  -0.25124D-01  -0.13316D-01   0.36706D-01   0.52843D-01
Accelerometers                       7     0.58854D-01   0.21551D-01  -0.25124D-01  -0.13316D-01   0.36706D-01   0.52843D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors            6     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors            6     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors            6     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors            6     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors            6     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Second Mirror                        9     0.66947D-01  -0.57165D-02   0.45950D-02  -0.23440D-01  -0.53303D-01   0.25302D+00
Second Mirror                        9     0.66947D-01  -0.57165D-02   0.45950D-02  -0.23440D-01  -0.53303D-01   0.25302D+00
Sensitive Instrument 2              10     0.29089D-01   0.16619D-02  -0.18698D-01  -0.16825D-01   0.35260D-01   0.63276D-01
Sensitive Instrument 2              10     0.29089D-01   0.16619D-02  -0.18698D-01  -0.16825D-01   0.35260D-01   0.63276D-01
Sensitive Instrument 3              11     0.91174D-01   0.33007D-01  -0.18345D-01  -0.16784D-01   0.34316D-01   0.56190D-01
Sensitive Instrument 4              12     0.76902D-01   0.39612D-01  -0.26600D-01  -0.16817D-01   0.34114D-01   0.56490D-01
Sensitive Instrument 5              13     0.72074D-01   0.33603D-01  -0.24411D-01  -0.16822D-01   0.34138D-01   0.56495D-01

MODE# 58/ 58, Frequency (rad/sec), Damping (zeta), Generalized Mass=    539.32       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.47060D-01  -0.45992D-01   0.13078D-01  -0.45612D-02   0.58825D-02   0.48097D-02
RCS Jet #2    (+X)                  22     0.87318D-03  -0.81399D-02   0.16008D-01  -0.78522D-02   0.14459D-01   0.20897D-02
RCS Jet #3    (+Y)                  23     0.12768D-01   0.46006D-02  -0.83088D-02  -0.64465D-02  -0.42365D-02   0.57128D-02
RCS Jet #4    (-Y)                  24     0.13400D-02   0.56069D-02  -0.25963D-01  -0.70884D-02   0.15150D-01   0.70150D-02
RCS Jet #5    (-Y)                  25    -0.22801D-02  -0.72681D-02   0.20493D-02  -0.73700D-02   0.13205D-01   0.64631D-02
RCS Jet #6    (+Y)                  26    -0.57670D-02  -0.37229D-02   0.14472D-01  -0.10257D-01   0.16955D-01  -0.21896D-01
RCS Jet #7    (+X)                  27    -0.73462D-01   0.11384D+00  -0.85686D-01  -0.27356D+00  -0.12840D+00  -0.39943D+00
RCS Jet #8    (+X)                  28    -0.11625D+00   0.19606D+00  -0.82793D-01  -0.27355D+00  -0.12840D+00  -0.39949D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.85012D-01  -0.21720D-01   0.42614D-01   0.33792D-01   0.72744D-01   0.56782D-01
Reaction Wheel #2 Spin Axis         18     0.22801D-02  -0.30769D-01   0.16294D-01  -0.50636D-01   0.45256D-03   0.47730D-01
Reaction Wheel #3 Spin Axis         19    -0.58248D-01  -0.61043D-01  -0.66123D-01  -0.81912D-01   0.52700D-01   0.35544D-02
Cryo Cooler Pump                     8     0.11630D-01  -0.14319D-01  -0.18113D-01  -0.29182D-02  -0.58709D-02   0.22057D-01
Cryo Cooler Pump                     8     0.11630D-01  -0.14319D-01  -0.18113D-01  -0.29182D-02  -0.58709D-02   0.22057D-01
Cryo Cooler Pump                     8     0.11630D-01  -0.14319D-01  -0.18113D-01  -0.29182D-02  -0.58709D-02   0.22057D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.12183D-01   0.21016D-02  -0.20344D-01  -0.14851D-02   0.10144D-01   0.26734D-02
Accelerometers                       7     0.12183D-01   0.21016D-02  -0.20344D-01  -0.14851D-02   0.10144D-01   0.26734D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.13911D-01  -0.20377D-02  -0.88629D-02   0.99047D-03   0.11042D-01   0.26636D-02
Inertial Attitude Sensors            6     0.13911D-01  -0.20377D-02  -0.88629D-02   0.99047D-03   0.11042D-01   0.26636D-02
Inertial Attitude Sensors            6     0.13911D-01  -0.20377D-02  -0.88629D-02   0.99047D-03   0.11042D-01   0.26636D-02
Inertial Attitude Sensors            6     0.13911D-01  -0.20377D-02  -0.88629D-02   0.99047D-03   0.11042D-01   0.26636D-02
Inertial Attitude Sensors            6     0.13911D-01  -0.20377D-02  -0.88629D-02   0.99047D-03   0.11042D-01   0.26636D-02
Inertial Attitude Sensors            6     0.13911D-01  -0.20377D-02  -0.88629D-02   0.99047D-03   0.11042D-01   0.26636D-02
Second Mirror                        9     0.41670D-02  -0.14442D-01  -0.18221D-01  -0.16176D-02  -0.58756D-02   0.22637D-01
Second Mirror                        9     0.41670D-02  -0.14442D-01  -0.18221D-01  -0.16176D-02  -0.58756D-02   0.22637D-01
Sensitive Instrument 2              10     0.18740D-01   0.32309D-02  -0.16626D-01  -0.21956D-02   0.11117D-01   0.38083D-02
Sensitive Instrument 2              10     0.18740D-01   0.32309D-02  -0.16626D-01  -0.21956D-02   0.11117D-01   0.38083D-02
Sensitive Instrument 3              11     0.21910D-01   0.46028D-02  -0.18792D-01  -0.24844D-02   0.10105D-01   0.23317D-02
Sensitive Instrument 4              12     0.21333D-01   0.48734D-02  -0.20606D-01  -0.24948D-02   0.10120D-01   0.23075D-02
Sensitive Instrument 5              13     0.19901D-01   0.43718D-02  -0.19956D-01  -0.24953D-02   0.10125D-01   0.23078D-02

MODE# 59/ 59, Frequency (rad/sec), Damping (zeta), Generalized Mass=    539.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.14551D+00   0.58785D-01  -0.30772D-01   0.59312D-02  -0.10100D-01  -0.58792D-02
RCS Jet #2    (+X)                  22    -0.17026D-01   0.48379D-01  -0.62106D-01   0.40991D-02  -0.26357D-01  -0.34513D-01
RCS Jet #3    (+Y)                  23    -0.49956D-01  -0.32217D-01   0.27140D-01   0.14966D-02  -0.19897D-01  -0.28836D-01
RCS Jet #4    (-Y)                  24     0.34099D-02  -0.34718D-01   0.35738D-01   0.55860D-02  -0.35315D-01  -0.35351D-01
RCS Jet #5    (-Y)                  25     0.28320D-01   0.35960D-01  -0.43236D-01   0.51466D-02  -0.22388D-01  -0.94936D-01
RCS Jet #6    (+Y)                  26    -0.19952D-01   0.20470D-01  -0.49844D-01   0.40330D-02  -0.25109D-01   0.28213D-01
RCS Jet #7    (+X)                  27     0.18361D+00  -0.31102D+00   0.16306D+00   0.66389D+00   0.27788D+00   0.99407D+00
RCS Jet #8    (+X)                  28     0.27622D+00  -0.51000D+00   0.15681D+00   0.66386D+00   0.27791D+00   0.99421D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.28800D+00   0.75729D-01  -0.20323D+00  -0.18817D+00  -0.28343D+00  -0.33989D+00
Reaction Wheel #2 Spin Axis         18     0.72836D-01  -0.32862D-01   0.26926D-01  -0.33882D-01  -0.23788D-01   0.81362D-04
Reaction Wheel #3 Spin Axis         19     0.11011D+00  -0.48968D-01  -0.11646D-01   0.38368D-01   0.10995D+00  -0.24194D+00
Cryo Cooler Pump                     8    -0.49134D-01   0.11615D-01  -0.43955D-02   0.13919D-01   0.21852D-01  -0.11940D+00
Cryo Cooler Pump                     8    -0.49134D-01   0.11615D-01  -0.43955D-02   0.13919D-01   0.21852D-01  -0.11940D+00
Cryo Cooler Pump                     8    -0.49134D-01   0.11615D-01  -0.43955D-02   0.13919D-01   0.21852D-01  -0.11940D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.42383D-01  -0.10371D-01   0.22981D-02   0.20183D-02  -0.40705D-01  -0.16074D-01
Accelerometers                       7    -0.42383D-01  -0.10371D-01   0.22981D-02   0.20183D-02  -0.40705D-01  -0.16074D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors            6    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors            6    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors            6    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors            6    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors            6    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Second Mirror                        9    -0.20821D-01  -0.21484D-02  -0.39781D-02   0.10780D-01   0.21966D-01  -0.12161D+00
Second Mirror                        9    -0.20821D-01  -0.21484D-02  -0.39781D-02   0.10780D-01   0.21966D-01  -0.12161D+00
Sensitive Instrument 2              10    -0.57472D-01  -0.45732D-02  -0.21564D-01   0.39901D-02  -0.40529D-01  -0.21439D-01
Sensitive Instrument 2              10    -0.57472D-01  -0.45732D-02  -0.21564D-01   0.39901D-02  -0.40529D-01  -0.21439D-01
Sensitive Instrument 3              11    -0.77550D-01  -0.13980D-01  -0.45911D-02   0.44854D-02  -0.37632D-01  -0.15930D-01
Sensitive Instrument 4              12    -0.73530D-01  -0.15820D-01   0.96906D-03   0.42950D-02  -0.37758D-01  -0.16357D-01
Sensitive Instrument 5              13    -0.68186D-01  -0.14162D-01  -0.14540D-02   0.42968D-02  -0.37783D-01  -0.16358D-01

MODE# 60/ 60, Frequency (rad/sec), Damping (zeta), Generalized Mass=    547.03       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.28059D-01  -0.71382D-02   0.61967D-02  -0.30302D-07   0.22674D-02   0.22763D-02
RCS Jet #2    (+X)                  22     0.95231D-02  -0.13249D-01   0.14058D-01  -0.30410D-03   0.71375D-02  -0.25206D-02
RCS Jet #3    (+Y)                  23     0.24458D-01   0.69644D-02  -0.91329D-02   0.38622D-03   0.10977D-01   0.36515D-03
RCS Jet #4    (-Y)                  24    -0.24491D-02   0.75210D-02  -0.12664D-01  -0.10318D-02   0.75042D-02   0.15248D-02
RCS Jet #5    (-Y)                  25     0.67697D-02  -0.16360D-01   0.97217D-02  -0.23239D-03   0.66288D-02   0.10682D-01
RCS Jet #6    (+Y)                  26     0.29421D-02  -0.12938D-01   0.10159D-01  -0.35222D-03   0.67674D-02  -0.16421D-01
RCS Jet #7    (+X)                  27    -0.40834D-01   0.67600D-01  -0.37847D-01  -0.14603D+00  -0.63031D-01  -0.22285D+00
RCS Jet #8    (+X)                  28    -0.61840D-01   0.11127D+00  -0.36429D-01  -0.14602D+00  -0.63036D-01  -0.22289D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.57912D-01  -0.16203D-01   0.39770D-01   0.36070D-01   0.60144D-01   0.64121D-01
Reaction Wheel #2 Spin Axis         18    -0.16732D-01   0.61074D-02  -0.12476D-01   0.12637D-01   0.10615D-01  -0.14491D-02
Reaction Wheel #3 Spin Axis         19    -0.30643D-01  -0.21207D-01  -0.28326D-01  -0.37370D-01   0.20830D-01   0.14669D-01
Cryo Cooler Pump                     8     0.27477D-01  -0.42369D-02   0.56107D-02  -0.53568D-02  -0.66793D-02   0.55970D-01
Cryo Cooler Pump                     8     0.27477D-01  -0.42369D-02   0.56107D-02  -0.53568D-02  -0.66793D-02   0.55970D-01
Cryo Cooler Pump                     8     0.27477D-01  -0.42369D-02   0.56107D-02  -0.53568D-02  -0.66793D-02   0.55970D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.11750D-01   0.50770D-02  -0.50665D-02  -0.38425D-02   0.93450D-02   0.98776D-02
Accelerometers                       7     0.11750D-01   0.50770D-02  -0.50665D-02  -0.38425D-02   0.93450D-02   0.98776D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.16350D-01  -0.67183D-02   0.52753D-02  -0.17905D-02   0.75206D-02   0.97010D-02
Inertial Attitude Sensors            6     0.16350D-01  -0.67183D-02   0.52753D-02  -0.17905D-02   0.75206D-02   0.97010D-02
Inertial Attitude Sensors            6     0.16350D-01  -0.67183D-02   0.52753D-02  -0.17905D-02   0.75206D-02   0.97010D-02
Inertial Attitude Sensors            6     0.16350D-01  -0.67183D-02   0.52753D-02  -0.17905D-02   0.75206D-02   0.97010D-02
Inertial Attitude Sensors            6     0.16350D-01  -0.67183D-02   0.52753D-02  -0.17905D-02   0.75206D-02   0.97010D-02
Inertial Attitude Sensors            6     0.16350D-01  -0.67183D-02   0.52753D-02  -0.17905D-02   0.75206D-02   0.97010D-02
Second Mirror                        9     0.18785D-01   0.15074D-02   0.54277D-02  -0.49510D-02  -0.65994D-02   0.56592D-01
Second Mirror                        9     0.18785D-01   0.15074D-02   0.54277D-02  -0.49510D-02  -0.65994D-02   0.56592D-01
Sensitive Instrument 2              10     0.81162D-02   0.26142D-02  -0.40479D-02  -0.50303D-02   0.88306D-02   0.12149D-01
Sensitive Instrument 2              10     0.81162D-02   0.26142D-02  -0.40479D-02  -0.50303D-02   0.88306D-02   0.12149D-01
Sensitive Instrument 3              11     0.20043D-01   0.84967D-02  -0.35559D-02  -0.45775D-02   0.87192D-02   0.10622D-01
Sensitive Instrument 4              12     0.17345D-01   0.97432D-02  -0.57325D-02  -0.45922D-02   0.86514D-02   0.10706D-01
Sensitive Instrument 5              13     0.16120D-01   0.84052D-02  -0.51773D-02  -0.45931D-02   0.86569D-02   0.10707D-01

MODE# 61/ 61, Frequency (rad/sec), Damping (zeta), Generalized Mass=    547.35       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.57791D-02   0.70321D-02  -0.45031D-03   0.13526D-02   0.89051D-03  -0.54006D-03
RCS Jet #2    (+X)                  22    -0.71709D-03   0.24538D-02  -0.64294D-02   0.14054D-02  -0.35686D-02  -0.40597D-02
RCS Jet #3    (+Y)                  23    -0.45356D-02  -0.21568D-02   0.10464D-02  -0.66959D-03  -0.13144D-02   0.24434D-02
RCS Jet #4    (-Y)                  24     0.15642D-03  -0.28670D-02  -0.39811D-03   0.29186D-03  -0.33349D-02   0.45502D-03
RCS Jet #5    (-Y)                  25     0.41645D-02   0.75711D-03  -0.33260D-02   0.12286D-02  -0.28339D-02  -0.97296D-02
RCS Jet #6    (+Y)                  26    -0.24570D-02  -0.44938D-03  -0.57649D-02   0.20770D-02  -0.46297D-02  -0.51418D-03
RCS Jet #7    (+X)                  27     0.25724D-01  -0.28033D-01   0.36988D-01   0.56167D-01   0.55266D-01   0.86773D-01
RCS Jet #8    (+X)                  28     0.44140D-01  -0.44807D-01   0.35745D-01   0.56165D-01   0.55268D-01   0.86785D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.35306D-01   0.11850D-01  -0.28472D-01  -0.30906D-01  -0.38588D-01  -0.54106D-01
Reaction Wheel #2 Spin Axis         18     0.34021D-02   0.11067D-02  -0.32741D-02   0.25104D-02  -0.13872D-02  -0.34074D-02
Reaction Wheel #3 Spin Axis         19     0.32805D-02  -0.10042D-01  -0.10450D-01  -0.86140D-02   0.17214D-01  -0.18662D-01
Cryo Cooler Pump                     8    -0.44291D-02   0.51699D-02   0.71626D-02   0.21859D-02   0.23453D-02  -0.47908D-02
Cryo Cooler Pump                     8    -0.44291D-02   0.51699D-02   0.71626D-02   0.21859D-02   0.23453D-02  -0.47908D-02
Cryo Cooler Pump                     8    -0.44291D-02   0.51699D-02   0.71626D-02   0.21859D-02   0.23453D-02  -0.47908D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.31416D-02  -0.60233D-03  -0.30679D-02  -0.37249D-02  -0.25320D-02  -0.13259D-02
Accelerometers                       7    -0.31416D-02  -0.60233D-03  -0.30679D-02  -0.37249D-02  -0.25320D-02  -0.13259D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.35375D-02   0.14238D-02  -0.29099D-02  -0.54965D-02  -0.17494D-02  -0.11774D-02
Inertial Attitude Sensors            6    -0.35375D-02   0.14238D-02  -0.29099D-02  -0.54965D-02  -0.17494D-02  -0.11774D-02
Inertial Attitude Sensors            6    -0.35375D-02   0.14238D-02  -0.29099D-02  -0.54965D-02  -0.17494D-02  -0.11774D-02
Inertial Attitude Sensors            6    -0.35375D-02   0.14238D-02  -0.29099D-02  -0.54965D-02  -0.17494D-02  -0.11774D-02
Inertial Attitude Sensors            6    -0.35375D-02   0.14238D-02  -0.29099D-02  -0.54965D-02  -0.17494D-02  -0.11774D-02
Inertial Attitude Sensors            6    -0.35375D-02   0.14238D-02  -0.29099D-02  -0.54965D-02  -0.17494D-02  -0.11774D-02
Second Mirror                        9    -0.15988D-02   0.38020D-02   0.71069D-02   0.33688D-03   0.22225D-02  -0.51954D-02
Second Mirror                        9    -0.15988D-02   0.38020D-02   0.71069D-02   0.33688D-03   0.22225D-02  -0.51954D-02
Sensitive Instrument 2              10    -0.40821D-02   0.26834D-02  -0.93647D-02  -0.41467D-02  -0.31375D-02  -0.15626D-02
Sensitive Instrument 2              10    -0.40821D-02   0.26834D-02  -0.93647D-02  -0.41467D-02  -0.31375D-02  -0.15626D-02
Sensitive Instrument 3              11    -0.53803D-02   0.20558D-02  -0.38124D-02  -0.33042D-02  -0.24654D-02  -0.99493D-03
Sensitive Instrument 4              12    -0.51326D-02   0.19423D-02  -0.43563D-02  -0.33668D-02  -0.25568D-02  -0.10362D-02
Sensitive Instrument 5              13    -0.47709D-02   0.15316D-02  -0.45204D-02  -0.33668D-02  -0.25592D-02  -0.10356D-02

MODE# 62/ 62, Frequency (rad/sec), Damping (zeta), Generalized Mass=    548.73       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.30150D-01   0.11644D+00  -0.43652D-02   0.67948D-02   0.91152D-02   0.67628D-02
RCS Jet #2    (+X)                  22     0.40755D-01  -0.26385D-01  -0.29882D-01   0.44512D-01  -0.32296D-01  -0.76535D-01
RCS Jet #3    (+Y)                  23     0.44315D-01   0.13343D-02  -0.40250D-01   0.15383D-01   0.44976D-01   0.68706D-01
RCS Jet #4    (-Y)                  24    -0.72927D-02  -0.43979D-02  -0.27449D-01   0.16410D-01  -0.42946D-02   0.48692D-01
RCS Jet #5    (-Y)                  25     0.89454D-01  -0.74309D-01   0.20323D-01   0.40340D-01  -0.25590D-01  -0.57268D-01
RCS Jet #6    (+Y)                  26    -0.25236D-01  -0.68501D-01  -0.51022D-01   0.59351D-01  -0.54498D-01  -0.10669D+00
RCS Jet #7    (+X)                  27     0.31599D+00  -0.41712D+00   0.63206D+00   0.91181D+00   0.88518D+00   0.13577D+01
RCS Jet #8    (+X)                  28     0.61093D+00  -0.69057D+00   0.61213D+00   0.91177D+00   0.88514D+00   0.13579D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.29901D+00   0.18713D+00  -0.25067D+00  -0.34338D+00  -0.34980D+00  -0.60197D+00
Reaction Wheel #2 Spin Axis         18    -0.17426D+00   0.28265D+00  -0.28034D+00   0.41035D+00   0.77712D-01  -0.25942D+00
Reaction Wheel #3 Spin Axis         19    -0.34158D-01   0.11175D+00  -0.68913D-02  -0.57080D-01  -0.86454D-01   0.24010D+00
Cryo Cooler Pump                     8     0.55194D-01   0.10558D+00   0.14863D+00  -0.18901D-01  -0.75985D-03   0.19087D+00
Cryo Cooler Pump                     8     0.55194D-01   0.10558D+00   0.14863D+00  -0.18901D-01  -0.75985D-03   0.19087D+00
Cryo Cooler Pump                     8     0.55194D-01   0.10558D+00   0.14863D+00  -0.18901D-01  -0.75985D-03   0.19087D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.18522D-01  -0.16171D-01  -0.21236D-01  -0.52732D-01   0.15376D-01   0.23717D-01
Accelerometers                       7     0.18522D-01  -0.16171D-01  -0.21236D-01  -0.52732D-01   0.15376D-01   0.23717D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors            6     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors            6     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors            6     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors            6     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors            6     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Second Mirror                        9     0.52407D-01   0.15936D+00   0.14255D+00  -0.83406D-01  -0.34031D-02   0.18137D+00
Second Mirror                        9     0.52407D-01   0.15936D+00   0.14255D+00  -0.83406D-01  -0.34031D-02   0.18137D+00
Sensitive Instrument 2              10    -0.55652D-02  -0.48149D-02  -0.71081D-01  -0.49320D-01   0.50012D-02   0.33866D-01
Sensitive Instrument 2              10    -0.55652D-02  -0.48149D-02  -0.71081D-01  -0.49320D-01   0.50012D-02   0.33866D-01
Sensitive Instrument 3              11     0.29676D-01   0.15279D-01  -0.23272D-01  -0.45119D-01   0.92948D-02   0.32852D-01
Sensitive Instrument 4              12     0.21290D-01   0.19156D-01  -0.35794D-01  -0.45524D-01   0.84834D-02   0.32928D-01
Sensitive Instrument 5              13     0.20089D-01   0.10591D-01  -0.35249D-01  -0.45524D-01   0.84862D-02   0.32935D-01

MODE# 63/ 63, Frequency (rad/sec), Damping (zeta), Generalized Mass=    551.93       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.20391D-01   0.12696D+00  -0.74441D-02  -0.78715D-03   0.99016D-02   0.10323D-01
RCS Jet #2    (+X)                  22     0.53332D-01   0.76980D-02  -0.53413D-01   0.57668D-01  -0.64111D-01  -0.13836D+00
RCS Jet #3    (+Y)                  23     0.43266D-01   0.19031D-01  -0.29298D-01   0.10267D-01   0.59293D-01   0.10136D+00
RCS Jet #4    (-Y)                  24    -0.93101D-02   0.12643D-01  -0.46754D-01   0.12380D-01  -0.11149D-01   0.88684D-01
RCS Jet #5    (-Y)                  25     0.14288D+00  -0.78089D-01   0.23717D-01   0.49050D-01  -0.54521D-01  -0.10851D+00
RCS Jet #6    (+Y)                  26    -0.69889D-01  -0.66682D-01  -0.71503D-01   0.83575D-01  -0.10204D+00  -0.20497D+00
RCS Jet #7    (+X)                  27     0.65816D+00  -0.69116D+00   0.13167D+01   0.14750D+01   0.18322D+01   0.22225D+01
RCS Jet #8    (+X)                  28     0.12686D+01  -0.11329D+01   0.12754D+01   0.14749D+01   0.18322D+01   0.22228D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.59820D+00   0.34532D+00  -0.49298D+00  -0.72001D+00  -0.71430D+00  -0.12330D+01
Reaction Wheel #2 Spin Axis         18    -0.26993D+00   0.40567D+00  -0.39062D+00   0.58674D+00   0.63925D-01  -0.45685D+00
Reaction Wheel #3 Spin Axis         19    -0.78717D-01   0.86672D-01  -0.80700D-01  -0.18823D+00  -0.30226D-01   0.29260D+00
Cryo Cooler Pump                     8     0.86037D-01  -0.35076D-01   0.21671D+00  -0.36965D-01   0.35411D-01   0.30450D+00
Cryo Cooler Pump                     8     0.86037D-01  -0.35076D-01   0.21671D+00  -0.36965D-01   0.35411D-01   0.30450D+00
Cryo Cooler Pump                     8     0.86037D-01  -0.35076D-01   0.21671D+00  -0.36965D-01   0.35411D-01   0.30450D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.19291D-01   0.47968D-02  -0.25202D-01  -0.98742D-01   0.20202D-01   0.25194D-01
Accelerometers                       7     0.19291D-01   0.47968D-02  -0.25202D-01  -0.98742D-01   0.20202D-01   0.25194D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors            6     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors            6     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors            6     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors            6     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors            6     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Second Mirror                        9     0.12232D+00   0.92679D-02   0.22064D+00   0.94752D-02   0.35969D-01   0.31242D+00
Second Mirror                        9     0.12232D+00   0.92679D-02   0.22064D+00   0.94752D-02   0.35969D-01   0.31242D+00
Sensitive Instrument 2              10    -0.78201D-02   0.47899D-01  -0.12895D+00  -0.10620D+00  -0.54065D-03   0.36991D-01
Sensitive Instrument 2              10    -0.78201D-02   0.47899D-01  -0.12895D+00  -0.10620D+00  -0.54065D-03   0.36991D-01
Sensitive Instrument 3              11     0.32569D-01   0.69185D-01  -0.29053D-01  -0.88744D-01   0.10743D-01   0.37842D-01
Sensitive Instrument 4              12     0.22855D-01   0.73649D-01  -0.52731D-01  -0.89712D-01   0.88006D-02   0.38104D-01
Sensitive Instrument 5              13     0.21608D-01   0.58488D-01  -0.52165D-01  -0.89717D-01   0.88009D-02   0.38123D-01

MODE# 64/ 64, Frequency (rad/sec), Damping (zeta), Generalized Mass=    553.02       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.95211D-01  -0.16260D-01  -0.16792D-01  -0.46332D-03  -0.71477D-02   0.55070D-02
RCS Jet #2    (+X)                  22    -0.76272D-02   0.11451D-01  -0.22990D-01  -0.36025D-02  -0.58102D-02   0.87275D-02
RCS Jet #3    (+Y)                  23    -0.22559D-01  -0.12443D-01   0.19656D-01  -0.17782D-02  -0.13937D-01  -0.24607D-02
RCS Jet #4    (-Y)                  24     0.97164D-02  -0.12079D-01   0.21231D-01  -0.12259D-02  -0.76082D-02  -0.20015D-02
RCS Jet #5    (-Y)                  25    -0.36724D-02   0.20230D-01  -0.21476D-01  -0.17951D-02  -0.40150D-02  -0.20842D-01
RCS Jet #6    (+Y)                  26     0.78730D-02   0.13323D-01  -0.15701D-01  -0.63877D-02  -0.20071D-02   0.35334D-01
RCS Jet #7    (+X)                  27     0.76977D-01  -0.28560D-01   0.49973D-01   0.46973D-01   0.92395D-01   0.80372D-01
RCS Jet #8    (+X)                  28     0.10777D+00  -0.42413D-01   0.47894D-01   0.46970D-01   0.92400D-01   0.80384D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.14255D+00   0.23238D-01  -0.99368D-01  -0.86694D-01  -0.14957D+00  -0.14692D+00
Reaction Wheel #2 Spin Axis         18     0.91372D-01  -0.63395D-01   0.74646D-01  -0.12701D+00   0.46393D-02   0.12650D+00
Reaction Wheel #3 Spin Axis         19     0.56183D-01  -0.67322D-02   0.17514D-01   0.42330D-01   0.26310D-01  -0.93295D-01
Cryo Cooler Pump                     8    -0.35878D-01   0.41005D-02  -0.24333D-01   0.43084D-02  -0.24152D-02  -0.99379D-01
Cryo Cooler Pump                     8    -0.35878D-01   0.41005D-02  -0.24333D-01   0.43084D-02  -0.24152D-02  -0.99379D-01
Cryo Cooler Pump                     8    -0.35878D-01   0.41005D-02  -0.24333D-01   0.43084D-02  -0.24152D-02  -0.99379D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.13688D-01  -0.12621D-01   0.85848D-02   0.12308D-01  -0.21218D-01  -0.12427D-01
Accelerometers                       7    -0.13688D-01  -0.12621D-01   0.85848D-02   0.12308D-01  -0.21218D-01  -0.12427D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors            6    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors            6    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors            6    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors            6    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors            6    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Second Mirror                        9    -0.37093D-01  -0.45397D-03  -0.24643D-01  -0.48727D-03  -0.23756D-02  -0.10064D+00
Second Mirror                        9    -0.37093D-01  -0.45397D-03  -0.24643D-01  -0.48727D-03  -0.23756D-02  -0.10064D+00
Sensitive Instrument 2              10    -0.15490D-01  -0.15459D-01   0.10647D-01   0.15956D-01  -0.18888D-01  -0.15859D-01
Sensitive Instrument 2              10    -0.15490D-01  -0.15459D-01   0.10647D-01   0.15956D-01  -0.18888D-01  -0.15859D-01
Sensitive Instrument 3              11    -0.31806D-01  -0.22720D-01   0.62660D-02   0.12790D-01  -0.19614D-01  -0.13854D-01
Sensitive Instrument 4              12    -0.28278D-01  -0.24342D-01   0.11790D-01   0.12884D-01  -0.19344D-01  -0.14041D-01
Sensitive Instrument 5              13    -0.25539D-01  -0.21614D-01   0.10549D-01   0.12887D-01  -0.19352D-01  -0.14045D-01

MODE# 65/ 65, Frequency (rad/sec), Damping (zeta), Generalized Mass=    555.61       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.90011D-02   0.75303D-01   0.70232D-03   0.50699D-02   0.22814D-02   0.29840D-02
RCS Jet #2    (+X)                  22     0.14704D-01   0.10173D-01  -0.11486D-01   0.18428D-01  -0.17468D-01  -0.46613D-01
RCS Jet #3    (+Y)                  23     0.15179D-01   0.72774D-02  -0.14280D-01   0.95002D-02   0.19456D-01   0.19103D-01
RCS Jet #4    (-Y)                  24    -0.60134D-02   0.63607D-02  -0.22639D-02   0.88723D-02  -0.34130D-02   0.17867D-01
RCS Jet #5    (-Y)                  25     0.45782D-01  -0.18036D-01   0.10972D-01   0.15432D-01  -0.16621D-01  -0.39820D-01
RCS Jet #6    (+Y)                  26    -0.26110D-01  -0.14665D-01  -0.18057D-01   0.25289D-01  -0.26486D-01  -0.67841D-01
RCS Jet #7    (+X)                  27     0.24289D+00  -0.27535D+00   0.50173D+00   0.61507D+00   0.69094D+00   0.90949D+00
RCS Jet #8    (+X)                  28     0.47310D+00  -0.45996D+00   0.48617D+00   0.61505D+00   0.69091D+00   0.90962D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.19798D+00   0.13561D+00  -0.16275D+00  -0.25900D+00  -0.24444D+00  -0.45396D+00
Reaction Wheel #2 Spin Axis         18    -0.12264D+00   0.17299D+00  -0.15967D+00   0.25465D+00   0.19376D-01  -0.20242D+00
Reaction Wheel #3 Spin Axis         19    -0.17259D-01   0.89852D-01   0.27248D-01  -0.14782D-01  -0.89210D-01   0.17186D+00
Cryo Cooler Pump                     8     0.29412D-01  -0.33236D-02   0.46780D-01  -0.13955D-01   0.93320D-02   0.89352D-01
Cryo Cooler Pump                     8     0.29412D-01  -0.33236D-02   0.46780D-01  -0.13955D-01   0.93320D-02   0.89352D-01
Cryo Cooler Pump                     8     0.29412D-01  -0.33236D-02   0.46780D-01  -0.13955D-01   0.93320D-02   0.89352D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.44813D-02   0.19306D-03   0.31312D-02  -0.16958D-01   0.70770D-02   0.97709D-02
Accelerometers                       7     0.44813D-02   0.19306D-03   0.31312D-02  -0.16958D-01   0.70770D-02   0.97709D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.81969D-02  -0.85683D-02   0.18611D-01  -0.24586D-01   0.28850D-02   0.10211D-01
Inertial Attitude Sensors            6     0.81969D-02  -0.85683D-02   0.18611D-01  -0.24586D-01   0.28850D-02   0.10211D-01
Inertial Attitude Sensors            6     0.81969D-02  -0.85683D-02   0.18611D-01  -0.24586D-01   0.28850D-02   0.10211D-01
Inertial Attitude Sensors            6     0.81969D-02  -0.85683D-02   0.18611D-01  -0.24586D-01   0.28850D-02   0.10211D-01
Inertial Attitude Sensors            6     0.81969D-02  -0.85683D-02   0.18611D-01  -0.24586D-01   0.28850D-02   0.10211D-01
Inertial Attitude Sensors            6     0.81969D-02  -0.85683D-02   0.18611D-01  -0.24586D-01   0.28850D-02   0.10211D-01
Second Mirror                        9     0.39277D-01   0.15362D-01   0.46974D-01  -0.89970D-02   0.94078D-02   0.90217D-01
Second Mirror                        9     0.39277D-01   0.15362D-01   0.46974D-01  -0.89970D-02   0.94078D-02   0.90217D-01
Sensitive Instrument 2              10    -0.50545D-02   0.12288D-02  -0.10865D-01  -0.15821D-01   0.26153D-02   0.13483D-01
Sensitive Instrument 2              10    -0.50545D-02   0.12288D-02  -0.10865D-01  -0.15821D-01   0.26153D-02   0.13483D-01
Sensitive Instrument 3              11     0.91902D-02   0.88067D-02   0.26147D-02  -0.13768D-01   0.43600D-02   0.13105D-01
Sensitive Instrument 4              12     0.58402D-02   0.10350D-01  -0.13802D-02  -0.13883D-01   0.40709D-02   0.13214D-01
Sensitive Instrument 5              13     0.52639D-02   0.75343D-02  -0.11189D-02  -0.13884D-01   0.40727D-02   0.13217D-01

MODE# 66/ 66, Frequency (rad/sec), Damping (zeta), Generalized Mass=    569.50       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.40756D-02  -0.14112D+00  -0.17607D-01  -0.22164D-01  -0.26225D-02  -0.14932D-01
RCS Jet #2    (+X)                  22    -0.21356D-01  -0.33864D-01  -0.11069D-01   0.10026D-01   0.53116D-02   0.11733D+00
RCS Jet #3    (+Y)                  23    -0.66432D-01   0.11115D-01   0.29452D-01  -0.21076D-01  -0.58292D-01   0.11667D+00
RCS Jet #4    (-Y)                  24     0.36217D-01   0.30203D-01  -0.35445D-01  -0.48190D-01   0.82420D-01   0.17058D+00
RCS Jet #5    (-Y)                  25    -0.82528D-01   0.38856D-01  -0.34863D-02   0.13284D-01   0.22027D-01   0.58271D-01
RCS Jet #6    (+Y)                  26     0.50886D-01   0.36146D-01  -0.24448D-01   0.13046D-01  -0.94994D-02   0.87989D-01
RCS Jet #7    (+X)                  27     0.84792D+00  -0.10164D+00   0.17782D+01  -0.65185D-01   0.24602D+01   0.12449D+00
RCS Jet #8    (+X)                  28     0.16676D+01  -0.77106D-01   0.17228D+01  -0.65186D-01   0.24601D+01   0.12449D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.60780D+00  -0.25467D+00   0.56487D+00   0.79032D+00   0.67381D+00   0.12983D+01
Reaction Wheel #2 Spin Axis         18     0.76576D+00  -0.72903D+00   0.10299D+01  -0.18784D+01   0.33440D-01   0.17348D+01
Reaction Wheel #3 Spin Axis         19     0.31333D-01   0.15091D+01   0.13331D+01   0.84760D+00  -0.27805D+01   0.33806D+01
Cryo Cooler Pump                     8    -0.12149D+00  -0.37543D-03  -0.27451D-01   0.95306D-02  -0.23248D-01  -0.23620D+00
Cryo Cooler Pump                     8    -0.12149D+00  -0.37543D-03  -0.27451D-01   0.95306D-02  -0.23248D-01  -0.23620D+00
Cryo Cooler Pump                     8    -0.12149D+00  -0.37543D-03  -0.27451D-01   0.95306D-02  -0.23248D-01  -0.23620D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.18985D-01  -0.35680D-01  -0.17765D-01  -0.60856D-03  -0.13966D-02  -0.51331D-01
Accelerometers                       7     0.18985D-01  -0.35680D-01  -0.17765D-01  -0.60856D-03  -0.13966D-02  -0.51331D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors            6    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors            6    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors            6    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors            6    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors            6    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Second Mirror                        9    -0.14824D+00  -0.15029D-01  -0.27475D-01   0.87893D-02  -0.24426D-01  -0.23596D+00
Second Mirror                        9    -0.14824D+00  -0.15029D-01  -0.27475D-01   0.87893D-02  -0.24426D-01  -0.23596D+00
Sensitive Instrument 2              10     0.79557D-01  -0.55098D-02  -0.17422D-01   0.39287D-02   0.62918D-03  -0.56540D-01
Sensitive Instrument 2              10     0.79557D-01  -0.55098D-02  -0.17422D-01   0.39287D-02   0.62918D-03  -0.56540D-01
Sensitive Instrument 3              11     0.18963D-01  -0.34233D-01  -0.16925D-01   0.77330D-03  -0.39476D-02  -0.56394D-01
Sensitive Instrument 4              12     0.33371D-01  -0.40906D-01  -0.16321D-01   0.99228D-03  -0.34774D-02  -0.56465D-01
Sensitive Instrument 5              13     0.33866D-01  -0.37141D-01  -0.16544D-01   0.99808D-03  -0.34652D-02  -0.56468D-01

MODE# 67/ 67, Frequency (rad/sec), Damping (zeta), Generalized Mass=    575.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.82998D-01  -0.15318D+00   0.94450D-01  -0.18082D-01  -0.10065D-01  -0.26250D-02
RCS Jet #2    (+X)                  22    -0.18560D-01  -0.18753D-01   0.12832D+00  -0.45370D-02   0.46276D-01   0.10697D+00
RCS Jet #3    (+Y)                  23     0.27675D-01   0.15783D-01   0.79438D-01  -0.23596D-02  -0.60739D-02  -0.60992D-01
RCS Jet #4    (-Y)                  24    -0.16718D-01   0.39392D-01   0.75286D-01  -0.31974D-01   0.81376D-01   0.79627D-02
RCS Jet #5    (-Y)                  25    -0.78837D-01   0.46696D-01   0.10105D+00   0.35092D-03   0.53306D-01   0.64822D-01
RCS Jet #6    (+Y)                  26     0.44889D-01   0.47728D-01   0.10623D+00  -0.95224D-02   0.44111D-01   0.70211D-01
RCS Jet #7    (+X)                  27     0.16850D+01  -0.11462D+00   0.38511D+01  -0.19008D-01   0.51247D+01   0.16128D+00
RCS Jet #8    (+X)                  28     0.33924D+01  -0.10466D+00   0.37357D+01  -0.19012D-01   0.51245D+01   0.16129D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.39539D+00   0.28455D+00  -0.28519D+00  -0.89810D+00  -0.59938D+00  -0.15064D+01
Reaction Wheel #2 Spin Axis         18    -0.55572D-01  -0.22243D+00   0.32645D+00  -0.35324D+00  -0.46670D+00  -0.39608D+00
Reaction Wheel #3 Spin Axis         19    -0.47606D+00  -0.10504D+01  -0.88536D+00  -0.10959D+01   0.15294D+01  -0.11802D+01
Cryo Cooler Pump                     8    -0.13109D-01  -0.76057D-02  -0.11719D+00  -0.17444D-01  -0.63827D-01  -0.14041D+00
Cryo Cooler Pump                     8    -0.13109D-01  -0.76057D-02  -0.11719D+00  -0.17444D-01  -0.63827D-01  -0.14041D+00
Cryo Cooler Pump                     8    -0.13109D-01  -0.76057D-02  -0.11719D+00  -0.17444D-01  -0.63827D-01  -0.14041D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.11359D-01  -0.15862D-01   0.15086D+00   0.10643D+00   0.17614D-01   0.55508D-02
Accelerometers                       7     0.11359D-01  -0.15862D-01   0.15086D+00   0.10643D+00   0.17614D-01   0.55508D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors            6     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors            6     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors            6     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors            6     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors            6     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Second Mirror                        9    -0.86208D-01   0.82360D-02  -0.11870D+00  -0.19297D-01  -0.62396D-01  -0.13831D+00
Second Mirror                        9    -0.86208D-01   0.82360D-02  -0.11870D+00  -0.19297D-01  -0.62396D-01  -0.13831D+00
Sensitive Instrument 2              10     0.28499D-01  -0.90935D-01   0.29969D+00   0.11743D+00   0.35693D-01   0.10821D-02
Sensitive Instrument 2              10     0.28499D-01  -0.90935D-01   0.29969D+00   0.11743D+00   0.35693D-01   0.10821D-02
Sensitive Instrument 3              11     0.26295D-01  -0.89949D-01   0.16543D+00   0.93775D-01   0.21124D-01  -0.55847D-02
Sensitive Instrument 4              12     0.27792D-01  -0.90687D-01   0.18654D+00   0.95603D-01   0.23724D-01  -0.44590D-02
Sensitive Instrument 5              13     0.24439D-01  -0.76849D-01   0.18806D+00   0.95608D-01   0.23764D-01  -0.44798D-02

MODE# 68/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    593.08       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.12613D+00  -0.22871D+00   0.61817D-01  -0.25938D-01   0.71347D-02  -0.24271D-01
RCS Jet #2    (+X)                  22    -0.15241D-01  -0.12074D+00   0.78065D-01   0.16487D-01   0.30434D-01   0.23156D+00
RCS Jet #3    (+Y)                  23    -0.19946D-01   0.44722D-01   0.23030D-01  -0.11262D-01   0.15310D-01   0.88562D-01
RCS Jet #4    (-Y)                  24    -0.28740D-02   0.63431D-01   0.13527D-02  -0.37360D-01   0.68801D-01   0.14603D+00
RCS Jet #5    (-Y)                  25    -0.17477D+00   0.10280D-01   0.78443D-01   0.23609D-01   0.54797D-01   0.22506D+00
RCS Jet #6    (+Y)                  26     0.14486D+00   0.11204D-01   0.43008D-01   0.22582D-01   0.51726D-02   0.22470D+00
RCS Jet #7    (+X)                  27    -0.21313D+01   0.50662D-02  -0.42881D+01  -0.42931D+00  -0.59350D+01  -0.33864D+00
RCS Jet #8    (+X)                  28    -0.41086D+01   0.14058D+00  -0.41544D+01  -0.42930D+00  -0.59347D+01  -0.33871D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.12973D+01   0.65161D+00  -0.11847D+01  -0.23640D+01  -0.18709D+01  -0.38200D+01
Reaction Wheel #2 Spin Axis         18     0.84628D-01  -0.23086D+00   0.29416D+00  -0.47521D+00  -0.25231D+00   0.10854D+00
Reaction Wheel #3 Spin Axis         19    -0.12518D+00   0.51956D+00   0.44552D+00   0.21122D+00  -0.10893D+01   0.14509D+01
Cryo Cooler Pump                     8    -0.70930D-01   0.10789D-01  -0.35828D-01   0.39728D-02  -0.57173D-01  -0.16321D+00
Cryo Cooler Pump                     8    -0.70930D-01   0.10789D-01  -0.35828D-01   0.39728D-02  -0.57173D-01  -0.16321D+00
Cryo Cooler Pump                     8    -0.70930D-01   0.10789D-01  -0.35828D-01   0.39728D-02  -0.57173D-01  -0.16321D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.26476D-01  -0.20908D-01   0.61921D-01   0.39749D-01   0.29713D-01  -0.19393D-01
Accelerometers                       7     0.26476D-01  -0.20908D-01   0.61921D-01   0.39749D-01   0.29713D-01  -0.19393D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors            6     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors            6     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors            6     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors            6     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors            6     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Second Mirror                        9    -0.13901D+00   0.37551D-02  -0.36162D-01   0.51554D-02  -0.57451D-01  -0.15930D+00
Second Mirror                        9    -0.13901D+00   0.37551D-02  -0.36162D-01   0.51554D-02  -0.57451D-01  -0.15930D+00
Sensitive Instrument 2              10     0.78301D-01  -0.32666D-01   0.13405D+00   0.42572D-01   0.37932D-01  -0.22735D-01
Sensitive Instrument 2              10     0.78301D-01  -0.32666D-01   0.13405D+00   0.42572D-01   0.37932D-01  -0.22735D-01
Sensitive Instrument 3              11     0.51958D-01  -0.44459D-01   0.72831D-01   0.32358D-01   0.28508D-01  -0.27809D-01
Sensitive Instrument 4              12     0.59101D-01  -0.47812D-01   0.77574D-01   0.33366D-01   0.29846D-01  -0.26981D-01
Sensitive Instrument 5              13     0.54881D-01  -0.41351D-01   0.79489D-01   0.33370D-01   0.29886D-01  -0.26990D-01

MODE# 69/ 69, Frequency (rad/sec), Damping (zeta), Generalized Mass=    596.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.21233D-01   0.26477D+00   0.25745D-02   0.32950D-01   0.43993D-02   0.11255D-01
RCS Jet #2    (+X)                  22     0.16072D-01   0.63089D-01   0.64781D-02   0.30318D-01  -0.46859D-02  -0.97942D-01
RCS Jet #3    (+Y)                  23     0.28327D-01  -0.13434D-01  -0.49710D-01   0.34032D-01   0.82753D-01  -0.99191D-01
RCS Jet #4    (-Y)                  24    -0.26368D-01  -0.12163D-01   0.12774D-01   0.22516D-01  -0.52228D-02  -0.96522D-01
RCS Jet #5    (-Y)                  25     0.11004D+00   0.14347D-01   0.30971D-01   0.28865D-01  -0.22423D-03  -0.16711D+00
RCS Jet #6    (+Y)                  26    -0.25895D-01  -0.37380D-02  -0.15845D-01   0.36983D-01  -0.12149D-01  -0.17684D-01
RCS Jet #7    (+X)                  27    -0.11665D+01  -0.36806D+00  -0.24203D+01   0.10208D+01  -0.33101D+01   0.14267D+01
RCS Jet #8    (+X)                  28    -0.22693D+01  -0.67629D+00  -0.23458D+01   0.10207D+01  -0.33100D+01   0.14269D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.15719D+00   0.19975D+00   0.20066D+00  -0.30722D+00   0.31210D+00  -0.54608D+00
Reaction Wheel #2 Spin Axis         18     0.59187D+00  -0.70439D+00   0.94905D+00  -0.17162D+01  -0.35635D+00   0.88570D+00
Reaction Wheel #3 Spin Axis         19    -0.78839D-01  -0.39864D+00  -0.38437D+00  -0.38852D+00   0.87784D+00  -0.93102D+00
Cryo Cooler Pump                     8     0.12456D+00  -0.15394D-01   0.17428D-01  -0.22080D-01   0.78662D-01   0.23080D+00
Cryo Cooler Pump                     8     0.12456D+00  -0.15394D-01   0.17428D-01  -0.22080D-01   0.78662D-01   0.23080D+00
Cryo Cooler Pump                     8     0.12456D+00  -0.15394D-01   0.17428D-01  -0.22080D-01   0.78662D-01   0.23080D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.86287D-02   0.22313D-01   0.16263D-01   0.76986D-02   0.82218D-02   0.30162D-01
Accelerometers                       7    -0.86287D-02   0.22313D-01   0.16263D-01   0.76986D-02   0.82218D-02   0.30162D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors            6     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors            6     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors            6     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors            6     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors            6     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Second Mirror                        9     0.22018D+00   0.14567D-01   0.17097D-01  -0.22918D-01   0.78592D-01   0.21928D+00
Second Mirror                        9     0.22018D+00   0.14567D-01   0.17097D-01  -0.22918D-01   0.78592D-01   0.21928D+00
Sensitive Instrument 2              10    -0.39371D-01  -0.44211D-02   0.32259D-01   0.96696D-02   0.77461D-02   0.35473D-01
Sensitive Instrument 2              10    -0.39371D-01  -0.44211D-02   0.32259D-01   0.96696D-02   0.77461D-02   0.35473D-01
Sensitive Instrument 3              11    -0.21214D-02   0.13278D-01   0.16538D-01   0.89204D-02   0.86340D-02   0.34036D-01
Sensitive Instrument 4              12    -0.10803D-01   0.17297D-01   0.17805D-01   0.89608D-02   0.86204D-02   0.34156D-01
Sensitive Instrument 5              13    -0.12024D-01   0.16375D-01   0.18358D-01   0.89572D-02   0.86179D-02   0.34156D-01

MODE# 70/ 70, Frequency (rad/sec), Damping (zeta), Generalized Mass=    597.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.12185D-01   0.38100D+00  -0.50451D-03   0.42505D-01   0.16576D-01   0.35868D-01
RCS Jet #2    (+X)                  22     0.12546D-01   0.11722D+00  -0.44247D-01   0.29356D-01  -0.36583D-01  -0.19582D+00
RCS Jet #3    (+Y)                  23     0.49758D-02  -0.30441D-01  -0.65084D-01   0.37661D-01   0.69022D-01  -0.10990D+00
RCS Jet #4    (-Y)                  24    -0.41153D-01  -0.45730D-01   0.21909D-01   0.52403D-01  -0.65134D-01  -0.15354D+00
RCS Jet #5    (-Y)                  25     0.19241D+00   0.19912D-01  -0.52441D-02   0.23184D-01  -0.41987D-01  -0.31592D+00
RCS Jet #6    (+Y)                  26    -0.68317D-01  -0.16389D-01  -0.46944D-01   0.37660D-01  -0.35448D-01  -0.28241D-01
RCS Jet #7    (+X)                  27    -0.48049D+00  -0.39655D+00  -0.10943D+01   0.13228D+01  -0.14712D+01   0.17221D+01
RCS Jet #8    (+X)                  28    -0.97063D+00  -0.79883D+00  -0.10611D+01   0.13228D+01  -0.14711D+01   0.17224D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.33890D+00   0.88280D-01   0.39752D+00   0.20860D+00   0.66004D+00   0.31094D+00
Reaction Wheel #2 Spin Axis         18     0.10090D+01  -0.95332D+00   0.13224D+01  -0.25297D+01  -0.12520D+00   0.18760D+01
Reaction Wheel #3 Spin Axis         19     0.47450D-01  -0.67213D+00  -0.62866D+00  -0.44287D+00   0.16184D+01  -0.20017D+01
Cryo Cooler Pump                     8     0.11155D+00  -0.38578D-01   0.12287D-01  -0.35656D-01   0.10692D+00   0.25604D+00
Cryo Cooler Pump                     8     0.11155D+00  -0.38578D-01   0.12287D-01  -0.35656D-01   0.10692D+00   0.25604D+00
Cryo Cooler Pump                     8     0.11155D+00  -0.38578D-01   0.12287D-01  -0.35656D-01   0.10692D+00   0.25604D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.46549D-01   0.18806D-01  -0.10538D-01  -0.51830D-02  -0.10655D-01   0.32672D-01
Accelerometers                       7    -0.46549D-01   0.18806D-01  -0.10538D-01  -0.51830D-02  -0.10655D-01   0.32672D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors            6    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors            6    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors            6    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors            6    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors            6    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Second Mirror                        9     0.24009D+00   0.50534D-02   0.11726D-01  -0.36803D-01   0.10745D+00   0.24718D+00
Second Mirror                        9     0.24009D+00   0.50534D-02   0.11726D-01  -0.36803D-01   0.10745D+00   0.24718D+00
Sensitive Instrument 2              10    -0.10060D+00  -0.86645D-02  -0.22284D-01   0.22108D-02  -0.13661D-01   0.36893D-01
Sensitive Instrument 2              10    -0.10060D+00  -0.86645D-02  -0.22284D-01   0.22108D-02  -0.13661D-01   0.36893D-01
Sensitive Instrument 3              11    -0.57916D-01   0.11719D-01  -0.18025D-01   0.28160D-02  -0.86111D-02   0.40470D-01
Sensitive Instrument 4              12    -0.68274D-01   0.16551D-01  -0.16269D-01   0.24392D-02  -0.90560D-02   0.39978D-01
Sensitive Instrument 5              13    -0.66998D-01   0.14331D-01  -0.16850D-01   0.24362D-02  -0.90899D-02   0.39979D-01

MODE# 71/ 71, Frequency (rad/sec), Damping (zeta), Generalized Mass=    602.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.17715D+00   0.66167D-01   0.28753D-01   0.14339D-01   0.16813D-01   0.10174D-01
RCS Jet #2    (+X)                  22    -0.42814D-01   0.82758D-01   0.19739D-01  -0.37321D-01   0.19562D-01  -0.15640D+00
RCS Jet #3    (+Y)                  23    -0.23235D-01  -0.70945D-01  -0.21185D-01  -0.61426D-02  -0.24064D-01  -0.14662D+00
RCS Jet #4    (-Y)                  24    -0.35250D-01  -0.79610D-01  -0.18968D-01   0.30012D-01  -0.10493D+00  -0.16627D+00
RCS Jet #5    (-Y)                  25     0.26125D-01  -0.18944D-01  -0.21654D-01  -0.38743D-01  -0.23894D-02  -0.40799D-01
RCS Jet #6    (+Y)                  26    -0.15905D+00  -0.30484D-02   0.40578D-01  -0.44332D-01   0.41543D-01  -0.17584D+00
RCS Jet #7    (+X)                  27     0.12386D+01   0.21585D+00   0.27587D+01  -0.17077D+00   0.37438D+01  -0.52248D+00
RCS Jet #8    (+X)                  28     0.24859D+01   0.26103D+00   0.26744D+01  -0.17076D+00   0.37436D+01  -0.52253D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.59960D+00   0.32587D+00  -0.66020D+00  -0.12658D+01  -0.10051D+01  -0.20556D+01
Reaction Wheel #2 Spin Axis         18     0.41282D-01  -0.63490D+00   0.54831D+00  -0.74473D+00  -0.87942D+00  -0.70652D+00
Reaction Wheel #3 Spin Axis         19     0.32481D+00   0.41827D+00   0.56581D+00   0.10467D+01  -0.52708D+00  -0.30355D+00
Cryo Cooler Pump                     8     0.24668D+00  -0.65076D-02   0.53816D-01  -0.48860D-02   0.24522D+00   0.21584D+00
Cryo Cooler Pump                     8     0.24668D+00  -0.65076D-02   0.53816D-01  -0.48860D-02   0.24522D+00   0.21584D+00
Cryo Cooler Pump                     8     0.24668D+00  -0.65076D-02   0.53816D-01  -0.48860D-02   0.24522D+00   0.21584D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.31577D-01   0.15191D-01  -0.69454D-01  -0.19198D-01   0.19316D-01   0.18230D-01
Accelerometers                       7    -0.31577D-01   0.15191D-01  -0.69454D-01  -0.19198D-01   0.19316D-01   0.18230D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors            6    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors            6    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors            6    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors            6    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors            6    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Second Mirror                        9     0.55485D+00   0.11855D-01   0.54096D-01  -0.12233D-01   0.23694D+00   0.14100D+00
Second Mirror                        9     0.55485D+00   0.11855D-01   0.54096D-01  -0.12233D-01   0.23694D+00   0.14100D+00
Sensitive Instrument 2              10    -0.38149D-01   0.20430D-01  -0.85629D-01  -0.23668D-01   0.20702D-01   0.22474D-01
Sensitive Instrument 2              10    -0.38149D-01   0.20430D-01  -0.85629D-01  -0.23668D-01   0.20702D-01   0.22474D-01
Sensitive Instrument 3              11    -0.10610D-01   0.31263D-01  -0.72483D-01  -0.18090D-01   0.24742D-01   0.24004D-01
Sensitive Instrument 4              12    -0.16746D-01   0.34136D-01  -0.79922D-01  -0.18703D-01   0.23954D-01   0.23465D-01
Sensitive Instrument 5              13    -0.20144D-01   0.29979D-01  -0.78385D-01  -0.18707D-01   0.23933D-01   0.23470D-01

MODE# 72/ 72, Frequency (rad/sec), Damping (zeta), Generalized Mass=    604.05       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.21807D+00  -0.94793D-01  -0.52289D-01  -0.17741D-01  -0.30702D-01  -0.22207D-01
RCS Jet #2    (+X)                  22     0.50574D-02  -0.47107D-01  -0.19775D-01   0.24584D-01  -0.84929D-02   0.12244D+00
RCS Jet #3    (+Y)                  23    -0.26209D-01   0.20201D-01   0.45816D-01   0.11859D-02   0.24668D-02   0.95350D-01
RCS Jet #4    (-Y)                  24     0.29961D-01   0.33726D-01   0.26350D-01  -0.36674D-01   0.79303D-01   0.11947D+00
RCS Jet #5    (-Y)                  25    -0.67962D-01   0.25113D-01   0.68356D-02   0.28469D-01   0.11325D-01   0.87988D-01
RCS Jet #6    (+Y)                  26     0.74356D-01   0.28042D-01  -0.35937D-01   0.27768D-01  -0.26064D-01   0.74448D-01
RCS Jet #7    (+X)                  27    -0.95576D+00  -0.17999D+00  -0.21591D+01   0.12254D+00  -0.29076D+01   0.41134D+00
RCS Jet #8    (+X)                  28    -0.19244D+01  -0.21159D+00  -0.20936D+01   0.12253D+00  -0.29075D+01   0.41137D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.49888D+00  -0.29252D+00   0.52217D+00   0.10209D+01   0.76438D+00   0.16333D+01
Reaction Wheel #2 Spin Axis         18    -0.28630D+00   0.57942D+00  -0.61647D+00   0.10726D+01   0.44226D+00  -0.20599D+00
Reaction Wheel #3 Spin Axis         19    -0.22822D+00  -0.17872D+00  -0.24399D+00  -0.62498D+00   0.10272D-01   0.61360D+00
Cryo Cooler Pump                     8     0.11471D+00   0.93292D-01   0.59334D-01   0.53587D-01   0.73098D-01  -0.31976D+00
Cryo Cooler Pump                     8     0.11471D+00   0.93292D-01   0.59334D-01   0.53587D-01   0.73098D-01  -0.31976D+00
Cryo Cooler Pump                     8     0.11471D+00   0.93292D-01   0.59334D-01   0.53587D-01   0.73098D-01  -0.31976D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.20402D-01  -0.31692D-01   0.53878D-01   0.23790D-01  -0.11396D-01  -0.27948D-01
Accelerometers                       7     0.20402D-01  -0.31692D-01   0.53878D-01   0.23790D-01  -0.11396D-01  -0.27948D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors            6     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors            6     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors            6     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors            6     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors            6     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Second Mirror                        9     0.22429D+00   0.52381D-01   0.60469D-01   0.46994D-01   0.61708D-01  -0.40495D+00
Second Mirror                        9     0.22429D+00   0.52381D-01   0.60469D-01   0.46994D-01   0.61708D-01  -0.40495D+00
Sensitive Instrument 2              10     0.44863D-01  -0.37766D-01   0.83603D-01   0.34493D-01  -0.73787D-02  -0.29437D-01
Sensitive Instrument 2              10     0.44863D-01  -0.37766D-01   0.83603D-01   0.34493D-01  -0.73787D-02  -0.29437D-01
Sensitive Instrument 3              11     0.10984D-01  -0.51100D-01   0.56672D-01   0.24462D-01  -0.13897D-01  -0.31007D-01
Sensitive Instrument 4              12     0.18925D-01  -0.54795D-01   0.64408D-01   0.25199D-01  -0.12798D-01  -0.30624D-01
Sensitive Instrument 5              13     0.20742D-01  -0.49257D-01   0.63586D-01   0.25206D-01  -0.12778D-01  -0.30632D-01

MODE# 73/ 73, Frequency (rad/sec), Damping (zeta), Generalized Mass=    615.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.12136D+00  -0.40013D-01   0.28408D-01   0.10409D-01   0.65096D-02   0.44215D-02
RCS Jet #2    (+X)                  22    -0.48065D-01  -0.17921D+00   0.17096D-02   0.12247D-01  -0.22416D-01   0.35366D+00
RCS Jet #3    (+Y)                  23    -0.81080D-01   0.14722D+00  -0.19014D-01  -0.31693D-01  -0.11584D+00   0.26263D+00
RCS Jet #4    (-Y)                  24    -0.17770D-01   0.12609D+00   0.16742D-01   0.12018D-01   0.14717D-01   0.20202D+00
RCS Jet #5    (-Y)                  25    -0.33619D+00   0.10456D-01   0.21630D-01   0.57962D-02  -0.20296D-01   0.46325D+00
RCS Jet #6    (+Y)                  26     0.16346D+00   0.36481D-01   0.10085D-02   0.20104D-01  -0.41742D-01   0.24391D+00
RCS Jet #7    (+X)                  27     0.40826D+00   0.21487D+00   0.95461D+00  -0.74162D+00   0.12738D+01  -0.85915D+00
RCS Jet #8    (+X)                  28     0.83262D+00   0.44279D+00   0.92592D+00  -0.74159D+00   0.12737D+01  -0.85930D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.83610D+00  -0.32516D+00  -0.87794D+00   0.10353D+01  -0.14839D+01   0.18331D+01
Reaction Wheel #2 Spin Axis         18     0.10011D+01   0.56226D+00  -0.12173D+00  -0.10867D+01   0.31945D+01   0.56809D+01
Reaction Wheel #3 Spin Axis         19    -0.51972D+00  -0.29975D+00  -0.66030D+00  -0.13055D+01   0.19282D+00   0.98405D+00
Cryo Cooler Pump                     8    -0.15422D+00   0.59837D-01  -0.88599D-01   0.68972D-01  -0.83662D-01  -0.41760D+00
Cryo Cooler Pump                     8    -0.15422D+00   0.59837D-01  -0.88599D-01   0.68972D-01  -0.83662D-01  -0.41760D+00
Cryo Cooler Pump                     8    -0.15422D+00   0.59837D-01  -0.88599D-01   0.68972D-01  -0.83662D-01  -0.41760D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.42132D-02   0.69722D-02   0.18128D-01   0.29742D-01   0.40439D-01  -0.43266D-01
Accelerometers                       7    -0.42132D-02   0.69722D-02   0.18128D-01   0.29742D-01   0.40439D-01  -0.43266D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors            6    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors            6    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors            6    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors            6    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors            6    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Second Mirror                        9    -0.25128D+00  -0.27695D-01  -0.87985D-01   0.66259D-01  -0.88121D-01  -0.42774D+00
Second Mirror                        9    -0.25128D+00  -0.27695D-01  -0.87985D-01   0.66259D-01  -0.88121D-01  -0.42774D+00
Sensitive Instrument 2              10     0.80623D-01   0.14191D-01   0.84305D-01   0.35268D-01   0.44614D-01  -0.51550D-01
Sensitive Instrument 2              10     0.80623D-01   0.14191D-01   0.84305D-01   0.35268D-01   0.44614D-01  -0.51550D-01
Sensitive Instrument 3              11     0.27694D-01  -0.15067D-01   0.23648D-01   0.31879D-01   0.36088D-01  -0.53405D-01
Sensitive Instrument 4              12     0.41344D-01  -0.21419D-01   0.27429D-01   0.32590D-01   0.37178D-01  -0.52970D-01
Sensitive Instrument 5              13     0.36082D-01  -0.13401D-01   0.29815D-01   0.32592D-01   0.37204D-01  -0.52976D-01

MODE# 74/ 74, Frequency (rad/sec), Damping (zeta), Generalized Mass=    630.94       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.19509D-01  -0.71478D-01  -0.42749D-02  -0.12778D-01   0.13999D-02  -0.72695D-02
RCS Jet #2    (+X)                  22    -0.10368D-02  -0.57426D-02  -0.50785D-02  -0.67423D-02  -0.54979D-02   0.27218D-01
RCS Jet #3    (+Y)                  23     0.92473D-02   0.40782D-01  -0.57326D-03  -0.42540D-02  -0.99548D-02   0.14761D-01
RCS Jet #4    (-Y)                  24    -0.58570D-02   0.42989D-01  -0.25249D-02  -0.32328D-02   0.24004D-02   0.34210D-01
RCS Jet #5    (-Y)                  25    -0.21639D-01   0.96020D-02  -0.73825D-02  -0.80778D-02  -0.71736D-02   0.30768D-01
RCS Jet #6    (+Y)                  26     0.15473D-01   0.10939D-01   0.26041D-02  -0.59324D-02  -0.57601D-02   0.19132D-01
RCS Jet #7    (+X)                  27     0.21669D-01   0.29986D-01   0.35918D-01  -0.12586D+00   0.53150D-01  -0.14980D+00
RCS Jet #8    (+X)                  28     0.39376D-01   0.68577D-01   0.34718D-01  -0.12586D+00   0.53140D-01  -0.14982D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
