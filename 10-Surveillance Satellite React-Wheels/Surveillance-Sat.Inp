RCS Jet #3    (+Y)                  23     0.22158D-01   0.10908D+00  -0.65837D-01  -0.94949D-01   0.17374D-02   0.24251D-02
RCS Jet #4    (-Y)                  24     0.15209D-01   0.10908D+00  -0.33803D+00  -0.94950D-01   0.17364D-02   0.24222D-02
RCS Jet #5    (-Y)                  25     0.16745D-01   0.89595D-01  -0.26388D+00  -0.94950D-01   0.17362D-02   0.24246D-02
RCS Jet #6    (+Y)                  26     0.20180D-01   0.89595D-01  -0.12936D+00  -0.94950D-01   0.17365D-02   0.24251D-02
RCS Jet #7    (+X)                  27     0.12863D-01  -0.21798D+00  -0.19562D+00  -0.94985D-01   0.17402D-02   0.23369D-02
RCS Jet #8    (+X)                  28     0.13443D-01  -0.18627D+00  -0.19566D+00  -0.94985D-01   0.17402D-02   0.23369D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.12993D-01  -0.20055D+00  -0.20300D+00  -0.94950D-01   0.17365D-02   0.24235D-02
Reaction Wheel #2 Spin Axis         18     0.14833D-01  -0.19778D+00  -0.13292D+00  -0.94950D-01   0.17365D-02   0.24238D-02
Reaction Wheel #3 Spin Axis         19     0.11510D-01  -0.19757D+00  -0.26325D+00  -0.94950D-01   0.17365D-02   0.24236D-02
Cryo Cooler Pump                     8     0.25660D-01   0.25491D+00  -0.33121D-01  -0.94950D-01   0.17365D-02   0.24240D-02
Cryo Cooler Pump                     8     0.25660D-01   0.25491D+00  -0.33121D-01  -0.94950D-01   0.17365D-02   0.24240D-02
Cryo Cooler Pump                     8     0.25660D-01   0.25491D+00  -0.33121D-01  -0.94950D-01   0.17365D-02   0.24240D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.18445D-01   0.17973D+00  -0.26187D+00  -0.94950D-01   0.17365D-02   0.24240D-02
Accelerometers                       7     0.18445D-01   0.17973D+00  -0.26187D+00  -0.94950D-01   0.17365D-02   0.24240D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.19744D-01   0.17733D+00  -0.20927D+00  -0.94950D-01   0.17364D-02   0.24240D-02
Inertial Attitude Sensors            6     0.19744D-01   0.17733D+00  -0.20927D+00  -0.94950D-01   0.17364D-02   0.24240D-02
Inertial Attitude Sensors            6     0.19744D-01   0.17733D+00  -0.20927D+00  -0.94950D-01   0.17364D-02   0.24240D-02
Inertial Attitude Sensors            6     0.19744D-01   0.17733D+00  -0.20927D+00  -0.94950D-01   0.17364D-02   0.24240D-02
Inertial Attitude Sensors            6     0.19744D-01   0.17733D+00  -0.20927D+00  -0.94950D-01   0.17364D-02   0.24240D-02
Inertial Attitude Sensors            6     0.19744D-01   0.17733D+00  -0.20927D+00  -0.94950D-01   0.17364D-02   0.24240D-02
Second Mirror                        9     0.27684D-01   0.36809D+00  -0.34902D-01  -0.94950D-01   0.17365D-02   0.24240D-02
Second Mirror                        9     0.27684D-01   0.36809D+00  -0.34902D-01  -0.94950D-01   0.17365D-02   0.24240D-02
Sensitive Instrument 2              10     0.17135D-01   0.24638D+00  -0.36095D+00  -0.94950D-01   0.17365D-02   0.24240D-02
Sensitive Instrument 2              10     0.17135D-01   0.24638D+00  -0.36095D+00  -0.94950D-01   0.17365D-02   0.24240D-02
Sensitive Instrument 3              11     0.19879D-01   0.25796D+00  -0.26173D+00  -0.94950D-01   0.17365D-02   0.24240D-02
Sensitive Instrument 4              12     0.19262D-01   0.25824D+00  -0.28612D+00  -0.94950D-01   0.17365D-02   0.24240D-02
Sensitive Instrument 5              13     0.19016D-01   0.24464D+00  -0.28601D+00  -0.94950D-01   0.17365D-02   0.24240D-02

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.73713D-01  -0.61043D-01  -0.10792D+00  -0.84952D-02  -0.70267D-01  -0.37200D-02
RCS Jet #2    (+X)                  22    -0.53748D+00  -0.49759D-02  -0.10792D+00  -0.84962D-02  -0.70267D-01  -0.37175D-02
RCS Jet #3    (+Y)                  23    -0.55175D+00  -0.17411D-01   0.15956D+00  -0.84949D-02  -0.70267D-01  -0.37199D-02
RCS Jet #4    (-Y)                  24    -0.54108D+00  -0.17411D-01   0.13521D+00  -0.84952D-02  -0.70267D-01  -0.37208D-02
RCS Jet #5    (-Y)                  25    -0.53484D+00  -0.71140D-02  -0.73532D-01  -0.84954D-02  -0.70268D-01  -0.37182D-02
RCS Jet #6    (+Y)                  26    -0.54011D+00  -0.71142D-02  -0.61497D-01  -0.84952D-02  -0.70268D-01  -0.37166D-02
RCS Jet #7    (+X)                  27    -0.31086D+00  -0.32368D-01  -0.10792D+00  -0.85006D-02  -0.70265D-01  -0.37332D-02
RCS Jet #8    (+X)                  28    -0.33429D+00  -0.29618D-01  -0.10633D+00  -0.85006D-02  -0.70265D-01  -0.37332D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.32078D+00  -0.36995D-01   0.20510D-02  -0.84952D-02  -0.70267D-01  -0.37199D-02
Reaction Wheel #2 Spin Axis         18    -0.32361D+00  -0.41254D-01   0.88950D-01  -0.84952D-02  -0.70267D-01  -0.37199D-02
Reaction Wheel #3 Spin Axis         19    -0.31851D+00  -0.41569D-01   0.83266D-01  -0.84952D-02  -0.70267D-01  -0.37199D-02
Cryo Cooler Pump                     8    -0.66309D+00   0.50809D-03   0.75358D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02
Cryo Cooler Pump                     8    -0.66309D+00   0.50809D-03   0.75358D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02
Cryo Cooler Pump                     8    -0.66309D+00   0.50809D-03   0.75358D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.59795D+00  -0.74190D-02   0.76355D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02
Accelerometers                       7    -0.59795D+00  -0.74190D-02   0.76355D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.60012D+00  -0.33615D-02   0.46529D-02  -0.84952D-02  -0.70267D-01  -0.37200D-02
Inertial Attitude Sensors            6    -0.60012D+00  -0.33615D-02   0.46529D-02  -0.84952D-02  -0.70267D-01  -0.37200D-02
Inertial Attitude Sensors            6    -0.60012D+00  -0.33615D-02   0.46529D-02  -0.84952D-02  -0.70267D-01  -0.37200D-02
Inertial Attitude Sensors            6    -0.60012D+00  -0.33615D-02   0.46529D-02  -0.84952D-02  -0.70267D-01  -0.37200D-02
Inertial Attitude Sensors            6    -0.60012D+00  -0.33615D-02   0.46529D-02  -0.84952D-02  -0.70267D-01  -0.37200D-02
Inertial Attitude Sensors            6    -0.60012D+00  -0.33615D-02   0.46529D-02  -0.84952D-02  -0.70267D-01  -0.37200D-02
Second Mirror                        9    -0.74678D+00   0.10634D-01   0.75199D-01  -0.84953D-02  -0.70267D-01  -0.37201D-02
Second Mirror                        9    -0.74678D+00   0.10634D-01   0.75199D-01  -0.84953D-02  -0.70267D-01  -0.37201D-02
Sensitive Instrument 2              10    -0.64441D+00   0.85067D-03   0.26235D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02
Sensitive Instrument 2              10    -0.64441D+00   0.85067D-03   0.26235D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02
Sensitive Instrument 3              11    -0.65594D+00  -0.21339D-03   0.72677D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02
Sensitive Instrument 4              12    -0.65500D+00  -0.65325D-03   0.78822D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02
Sensitive Instrument 5              13    -0.64504D+00  -0.16180D-02   0.74313D-01  -0.84952D-02  -0.70267D-01  -0.37200D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.72571D-01   0.42125D+00  -0.73703D-01  -0.13740D-01   0.50149D-02  -0.12601D-01
RCS Jet #2    (+X)                  22    -0.39473D-01   0.51193D+00  -0.73703D-01  -0.13741D-01   0.50149D-02  -0.12598D-01
RCS Jet #3    (+Y)                  23    -0.56895D-01   0.46790D+00  -0.72230D-01  -0.13740D-01   0.50153D-02  -0.12600D-01
RCS Jet #4    (-Y)                  24    -0.20775D-01   0.46790D+00  -0.11162D+00  -0.13740D-01   0.50148D-02  -0.12600D-01
RCS Jet #5    (-Y)                  25    -0.30549D-01   0.50469D+00  -0.86320D-01  -0.13740D-01   0.50148D-02  -0.12598D-01
RCS Jet #6    (+Y)                  26    -0.48397D-01   0.50469D+00  -0.66854D-01  -0.13740D-01   0.50148D-02  -0.12599D-01
RCS Jet #7    (+X)                  27    -0.55645D-01   0.46755D+00  -0.73702D-01  -0.13646D-01   0.50165D-02  -0.12373D-01
RCS Jet #8    (+X)                  28    -0.53973D-01   0.47182D+00  -0.73815D-01  -0.13646D-01   0.50165D-02  -0.12373D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.54307D-01   0.44980D+00  -0.82255D-01  -0.13740D-01   0.50148D-02  -0.12600D-01
Reaction Wheel #2 Spin Axis         18    -0.63871D-01   0.43538D+00  -0.77567D-01  -0.13740D-01   0.50148D-02  -0.12600D-01
Reaction Wheel #3 Spin Axis         19    -0.46596D-01   0.43431D+00  -0.96831D-01  -0.13740D-01   0.50148D-02  -0.12600D-01
Cryo Cooler Pump                     8    -0.53090D-01   0.50503D+00  -0.61602D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Cryo Cooler Pump                     8    -0.53090D-01   0.50503D+00  -0.61602D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Cryo Cooler Pump                     8    -0.53090D-01   0.50503D+00  -0.61602D-01  -0.13740D-01   0.50149D-02  -0.12600D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.26816D-01   0.49020D+00  -0.96156D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Accelerometers                       7    -0.26816D-01   0.49020D+00  -0.96156D-01  -0.13740D-01   0.50149D-02  -0.12600D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.33533D-01   0.50390D+00  -0.83375D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Inertial Attitude Sensors            6    -0.33533D-01   0.50390D+00  -0.83375D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Inertial Attitude Sensors            6    -0.33533D-01   0.50390D+00  -0.83375D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Inertial Attitude Sensors            6    -0.33533D-01   0.50390D+00  -0.83375D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Inertial Attitude Sensors            6    -0.33533D-01   0.50390D+00  -0.83375D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Inertial Attitude Sensors            6    -0.33533D-01   0.50390D+00  -0.83375D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Second Mirror                        9    -0.46876D-01   0.52141D+00  -0.61859D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Second Mirror                        9    -0.46876D-01   0.52141D+00  -0.61859D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Sensitive Instrument 2              10    -0.99379D-02   0.50743D+00  -0.10770D+00  -0.13740D-01   0.50149D-02  -0.12600D-01
Sensitive Instrument 2              10    -0.99379D-02   0.50743D+00  -0.10770D+00  -0.13740D-01   0.50149D-02  -0.12600D-01
Sensitive Instrument 3              11    -0.22683D-01   0.50220D+00  -0.95886D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Sensitive Instrument 4              12    -0.19475D-01   0.50071D+00  -0.99979D-01  -0.13740D-01   0.50149D-02  -0.12600D-01
Sensitive Instrument 5              13    -0.20185D-01   0.49957D+00  -0.99657D-01  -0.13740D-01   0.50149D-02  -0.12600D-01

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.28492D-02  -0.14859D+00   0.44007D+00  -0.46730D-01   0.10680D-01  -0.69719D-02
RCS Jet #2    (+X)                  22     0.73338D-01   0.15983D+00   0.44007D+00  -0.46730D-01   0.10680D-01  -0.69710D-02
RCS Jet #3    (+Y)                  23     0.64703D-01   0.14044D+00   0.46825D+00  -0.46730D-01   0.10680D-01  -0.69714D-02
RCS Jet #4    (-Y)                  24     0.84689D-01   0.14044D+00   0.33429D+00  -0.46730D-01   0.10680D-01  -0.69726D-02
RCS Jet #5    (-Y)                  25     0.78276D-01   0.15582D+00   0.40083D+00  -0.46730D-01   0.10680D-01  -0.69708D-02
RCS Jet #6    (+Y)                  26     0.68400D-01   0.15582D+00   0.46703D+00  -0.46730D-01   0.10680D-01  -0.69714D-02
RCS Jet #7    (+X)                  27     0.38893D-01   0.91182D-02   0.44007D+00  -0.46724D-01   0.10671D-01  -0.69583D-02
RCS Jet #8    (+X)                  28     0.42451D-01   0.24536D-01   0.43983D+00  -0.46724D-01   0.10672D-01  -0.69583D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.40771D-01   0.48875D-02   0.42101D+00  -0.46730D-01   0.10680D-01  -0.69720D-02
Reaction Wheel #2 Spin Axis         18     0.35480D-01  -0.30950D-02   0.44425D+00  -0.46730D-01   0.10680D-01  -0.69719D-02
Reaction Wheel #3 Spin Axis         19     0.45038D-01  -0.36865D-02   0.37927D+00  -0.46730D-01   0.10680D-01  -0.69720D-02
Cryo Cooler Pump                     8     0.79200D-01   0.22231D+00   0.49651D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Cryo Cooler Pump                     8     0.79200D-01   0.22231D+00   0.49651D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Cryo Cooler Pump                     8     0.79200D-01   0.22231D+00   0.49651D+00  -0.46730D-01   0.10680D-01  -0.69718D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.87416D-01   0.18282D+00   0.38093D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Accelerometers                       7     0.87416D-01   0.18282D+00   0.38093D+00  -0.46730D-01   0.10680D-01  -0.69718D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.83719D-01   0.19050D+00   0.41748D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Inertial Attitude Sensors            6     0.83719D-01   0.19050D+00   0.41748D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Inertial Attitude Sensors            6     0.83719D-01   0.19050D+00   0.41748D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Inertial Attitude Sensors            6     0.83719D-01   0.19050D+00   0.41748D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Inertial Attitude Sensors            6     0.83719D-01   0.19050D+00   0.41748D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Inertial Attitude Sensors            6     0.83719D-01   0.19050D+00   0.41748D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Second Mirror                        9     0.92061D-01   0.27802D+00   0.49563D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Second Mirror                        9     0.92061D-01   0.27802D+00   0.49563D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Sensitive Instrument 2              10     0.10242D+00   0.22041D+00   0.33793D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Sensitive Instrument 2              10     0.10242D+00   0.22041D+00   0.33793D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Sensitive Instrument 3              11     0.96226D-01   0.22175D+00   0.38151D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Sensitive Instrument 4              12     0.98002D-01   0.22093D+00   0.36835D+00  -0.46730D-01   0.10680D-01  -0.69718D-02
Sensitive Instrument 5              13     0.96489D-01   0.21475D+00   0.36904D+00  -0.46730D-01   0.10680D-01  -0.69718D-02

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.65138D+00   0.19312D+00  -0.23523D+00   0.15032D-02  -0.96540D-01  -0.74906D-01
RCS Jet #2    (+X)                  22     0.14211D-01   0.18320D+00  -0.23523D+00   0.15029D-02  -0.96541D-01  -0.74905D-01
RCS Jet #3    (+Y)                  23    -0.10543D+00  -0.89156D-01   0.11338D+00   0.15037D-02  -0.96540D-01  -0.74908D-01
RCS Jet #4    (-Y)                  24     0.10930D+00  -0.89156D-01   0.11769D+00   0.15035D-02  -0.96540D-01  -0.74906D-01
RCS Jet #5    (-Y)                  25     0.67270D-01   0.14013D+00  -0.17866D+00   0.15032D-02  -0.96541D-01  -0.74908D-01
RCS Jet #6    (+Y)                  26    -0.38846D-01   0.14013D+00  -0.18079D+00   0.15035D-02  -0.96541D-01  -0.74903D-01
RCS Jet #7    (+X)                  27     0.32555D+00   0.18802D+00  -0.23523D+00   0.15413D-02  -0.96536D-01  -0.74814D-01
RCS Jet #8    (+X)                  28     0.29337D+00   0.18582D+00  -0.23306D+00   0.15413D-02  -0.96536D-01  -0.74814D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.31535D+00   0.70157D-01  -0.83503D-01   0.15035D-02  -0.96541D-01  -0.74908D-01
Reaction Wheel #2 Spin Axis         18     0.25849D+00  -0.15606D-01   0.25889D-01   0.15035D-02  -0.96541D-01  -0.74906D-01
Reaction Wheel #3 Spin Axis         19     0.36119D+00  -0.21963D-01   0.36143D-01   0.15038D-02  -0.96540D-01  -0.74908D-01
Cryo Cooler Pump                     8    -0.28087D+00   0.11676D-02  -0.65569D-02   0.15036D-02  -0.96542D-01  -0.74908D-01
Cryo Cooler Pump                     8    -0.28087D+00   0.11676D-02  -0.65569D-02   0.15036D-02  -0.96542D-01  -0.74908D-01
Cryo Cooler Pump                     8    -0.28087D+00   0.11676D-02  -0.65569D-02   0.15036D-02  -0.96542D-01  -0.74908D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.23625D-01  -0.20460D-01   0.26481D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Accelerometers                       7    -0.23625D-01  -0.20460D-01   0.26481D-01   0.15036D-02  -0.96541D-01  -0.74908D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.63880D-01   0.60811D-01  -0.79069D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Inertial Attitude Sensors            6    -0.63880D-01   0.60811D-01  -0.79069D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Inertial Attitude Sensors            6    -0.63880D-01   0.60811D-01  -0.79069D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Inertial Attitude Sensors            6    -0.63880D-01   0.60811D-01  -0.79069D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Inertial Attitude Sensors            6    -0.63880D-01   0.60811D-01  -0.79069D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Inertial Attitude Sensors            6    -0.63880D-01   0.60811D-01  -0.79069D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Second Mirror                        9    -0.39455D+00  -0.62478D-03  -0.65287D-02   0.15035D-02  -0.96542D-01  -0.74908D-01
Second Mirror                        9    -0.39455D+00  -0.62478D-03  -0.65287D-02   0.15035D-02  -0.96542D-01  -0.74908D-01
Sensitive Instrument 2              10    -0.13872D-01   0.22346D-01  -0.28491D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Sensitive Instrument 2              10    -0.13872D-01   0.22346D-01  -0.28491D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Sensitive Instrument 3              11    -0.10333D+00  -0.17775D-01   0.21421D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Sensitive Instrument 4              12    -0.84257D-01  -0.26632D-01   0.33219D-01   0.15036D-02  -0.96541D-01  -0.74908D-01
Sensitive Instrument 5              13    -0.70580D-01  -0.21612D-01   0.27024D-01   0.15036D-02  -0.96541D-01  -0.74908D-01

Inertial Coupling Coefficients (H-Parameters) File Name for the   4 gimbaling bodies     :  Surveillance-Sat.Hpr
----------------------------------------------------------------------------------------------------------------------------
FLEXIBLE SPACECRAFT FE MODEL ...
Flex Spacecraft with Gimbaling Telescope and Reaction Wheels (61-Only Flex)        
! Same as above, but has the 6 rigid-body modes removed.
! Only the 61 flex modes are included.

Number of Input Forces applied on flex structure nodes (N_force)                         :  8
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  1    21      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  2    22      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  3    23      0.000       1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  4    24      0.000      -1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  5    25      0.000      -1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  6    26      0.000       1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  7    27      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  8    28      1.000       0.000       0.000    

Number of Input Torques applied on flex structure nodes (N_torque)                       :  6
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)  RWA  :  1    17      1.000       0.000       0.0
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)  RWA  :  2    18      0.000       1.000       0.0    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)  RWA  :  3    19      0.000       0.000       1.0    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)  Dist :  4     8      1.000       0.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)  Dist :  5     8      0.000       1.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)  Dist :  6     8      0.000       0.000       1.000    

Number of Linear Sensors Measuring Translations on the flex structure nodes (N_transl)   :  2
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  1     7      1    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  2     7      2    3

Number of Gyro Sensors Measuring Rotations on the flex structure nodes (N_rotat)         : 13
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  1     6      1    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  2     6      2    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  3     6      3    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  4     6      1    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  5     6      2    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  6     6      3    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  7     9      2    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  8     9      3    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  9    10      2    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler): 10    10      3    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler): 11    11      1    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler): 12    12      2    1
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler): 13    13      3    1

Number of Flexible Modes (max=600), Mode Shapes and Mode Frequencies are included below  : 61

MODE#  1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.0998       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.43556D+00  -0.25842D-02   0.14383D+00  -0.11015D-02   0.64939D-01  -0.10968D-02
RCS Jet #2    (+X)                  22    -0.69445D-02   0.46878D-02   0.14383D+00  -0.11019D-02   0.64943D-01  -0.10976D-02
RCS Jet #3    (+Y)                  23    -0.25866D-03   0.84179D-03  -0.90543D-01  -0.11015D-02   0.64943D-01  -0.10969D-02
RCS Jet #4    (-Y)                  24     0.28867D-02   0.84191D-03  -0.93702D-01  -0.11023D-02   0.64944D-01  -0.10973D-02
RCS Jet #5    (-Y)                  25    -0.61695D-02   0.40557D-02   0.10571D+00  -0.11017D-02   0.64943D-01  -0.10902D-02
RCS Jet #6    (+Y)                  26    -0.77244D-02   0.40575D-02   0.10727D+00  -0.11019D-02   0.64943D-01  -0.11047D-02
RCS Jet #7    (+X)                  27    -0.21638D+00   0.11339D-02   0.14383D+00  -0.11013D-02   0.64937D-01  -0.10964D-02
RCS Jet #8    (+X)                  28    -0.19474D+00   0.14764D-02   0.14237D+00  -0.11013D-02   0.64937D-01  -0.10964D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.20700D+00  -0.43105D-03   0.41763D-01  -0.11013D-02   0.64943D-01  -0.10960D-02
Reaction Wheel #2 Spin Axis         18    -0.20783D+00  -0.16859D-02  -0.31758D-01  -0.11002D-02   0.64942D-01  -0.11005D-02
Reaction Wheel #3 Spin Axis         19    -0.20632D+00  -0.17810D-02  -0.38780D-01  -0.11033D-02   0.64942D-01  -0.10951D-02
Cryo Cooler Pump                     8     0.10119D+00   0.39271D-02  -0.98352D-02  -0.11022D-02   0.64950D-01  -0.10992D-02
Cryo Cooler Pump                     8     0.10119D+00   0.39271D-02  -0.98352D-02  -0.11022D-02   0.64950D-01  -0.10992D-02
Cryo Cooler Pump                     8     0.10119D+00   0.39271D-02  -0.98352D-02  -0.11022D-02   0.64950D-01  -0.10992D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.51889D-01   0.27108D-02  -0.32279D-01  -0.11017D-02   0.64943D-01  -0.10968D-02
Accelerometers                       7     0.51889D-01   0.27108D-02  -0.32279D-01  -0.11017D-02   0.64943D-01  -0.10968D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors            6     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors            6     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors            6     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors            6     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors            6     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Second Mirror                        9     0.17864D+00   0.52413D-02  -0.98558D-02  -0.11024D-02   0.64950D-01  -0.10994D-02
Second Mirror                        9     0.17864D+00   0.52413D-02  -0.98558D-02  -0.11024D-02   0.64950D-01  -0.10994D-02
Sensitive Instrument 2              10     0.99605D-01   0.41431D-02   0.46061D-02  -0.11016D-02   0.64944D-01  -0.10966D-02
Sensitive Instrument 2              10     0.99605D-01   0.41431D-02   0.46061D-02  -0.11016D-02   0.64944D-01  -0.10966D-02
Sensitive Instrument 3              11     0.10548D+00   0.36774D-02  -0.28874D-01  -0.11017D-02   0.64943D-01  -0.10968D-02
Sensitive Instrument 4              12     0.10576D+00   0.35477D-02  -0.36834D-01  -0.11017D-02   0.64943D-01  -0.10968D-02
Sensitive Instrument 5              13     0.96563D-01   0.34621D-02  -0.32667D-01  -0.11017D-02   0.64943D-01  -0.10968D-02

MODE#  2/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.5411       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.37725D-01   0.31797D-02   0.13276D+00  -0.43028D-03   0.61271D-02  -0.22520D-02
RCS Jet #2    (+X)                  22     0.27193D-02   0.60214D-02   0.13276D+00  -0.43066D-03   0.61273D-02  -0.22525D-02
RCS Jet #3    (+Y)                  23     0.26929D-03  -0.21087D-02   0.11112D+00  -0.43056D-03   0.61282D-02  -0.22529D-02
RCS Jet #4    (-Y)                  24     0.67275D-02  -0.21086D-02   0.10988D+00  -0.43058D-03   0.61284D-02  -0.22524D-02
RCS Jet #5    (-Y)                  25     0.43127D-02   0.47254D-02   0.12894D+00  -0.43081D-03   0.61271D-02  -0.22460D-02
RCS Jet #6    (+Y)                  26     0.11215D-02   0.47270D-02   0.12955D+00  -0.43045D-03   0.61271D-02  -0.22590D-02
RCS Jet #7    (+X)                  27    -0.17045D-01   0.46323D-02   0.13276D+00  -0.42980D-03   0.61273D-02  -0.22510D-02
RCS Jet #8    (+X)                  28    -0.15002D-01   0.47249D-02   0.13263D+00  -0.42980D-03   0.61273D-02  -0.22510D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.16055D-01   0.11559D-02   0.12312D+00  -0.43027D-03   0.61312D-02  -0.22522D-02
Reaction Wheel #2 Spin Axis         18    -0.17762D-01  -0.14244D-02   0.11643D+00  -0.43302D-03   0.61271D-02  -0.22524D-02
Reaction Wheel #3 Spin Axis         19    -0.14674D-01  -0.16130D-02   0.11532D+00  -0.42835D-03   0.61268D-02  -0.22524D-02
Cryo Cooler Pump                     8     0.91533D-02   0.13522D-02   0.11884D+00  -0.42720D-03   0.61309D-02  -0.22530D-02
Cryo Cooler Pump                     8     0.91533D-02   0.13522D-02   0.11884D+00  -0.42720D-03   0.61309D-02  -0.22530D-02
Cryo Cooler Pump                     8     0.91533D-02   0.13522D-02   0.11884D+00  -0.42720D-03   0.61309D-02  -0.22530D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.96649D-02   0.32260D-03   0.11594D+00  -0.43060D-03   0.61289D-02  -0.22528D-02
Accelerometers                       7     0.96649D-02   0.32260D-03   0.11594D+00  -0.43060D-03   0.61289D-02  -0.22528D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors            6     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors            6     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors            6     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors            6     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors            6     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Second Mirror                        9     0.16504D-01   0.18616D-02   0.11883D+00  -0.42714D-03   0.61309D-02  -0.22530D-02
Second Mirror                        9     0.16504D-01   0.18616D-02   0.11883D+00  -0.42714D-03   0.61309D-02  -0.22530D-02
Sensitive Instrument 2              10     0.16433D-01   0.19511D-02   0.11907D+00  -0.43080D-03   0.61288D-02  -0.22528D-02
Sensitive Instrument 2              10     0.16433D-01   0.19511D-02   0.11907D+00  -0.43080D-03   0.61288D-02  -0.22528D-02
Sensitive Instrument 3              11     0.14722D-01   0.79605D-03   0.11626D+00  -0.43069D-03   0.61288D-02  -0.22528D-02
Sensitive Instrument 4              12     0.15295D-01   0.52968D-03   0.11542D+00  -0.43068D-03   0.61288D-02  -0.22528D-02
Sensitive Instrument 5              13     0.14427D-01   0.61322D-03   0.11582D+00  -0.43068D-03   0.61288D-02  -0.22528D-02

MODE#  3/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.0845       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.73485D-02   0.36622D+00   0.39796D-02   0.86092D-01   0.10267D-02   0.14063D-01
RCS Jet #2    (+X)                  22    -0.57463D-03  -0.20222D+00   0.39797D-02   0.86134D-01   0.10267D-02   0.14083D-01
RCS Jet #3    (+Y)                  23     0.19767D-01  -0.16195D+00  -0.12320D+00   0.86128D-01   0.10306D-02   0.14112D-01
RCS Jet #4    (-Y)                  24    -0.20655D-01  -0.16195D+00   0.12370D+00   0.86128D-01   0.10206D-02   0.14116D-01
RCS Jet #5    (-Y)                  25    -0.10551D-01  -0.19412D+00   0.64401D-01   0.86135D-01   0.10288D-02   0.14084D-01
RCS Jet #6    (+Y)                  26     0.94020D-02  -0.19412D+00  -0.57622D-01   0.86134D-01   0.10248D-02   0.14086D-01
RCS Jet #7    (+X)                  27    -0.38852D-02   0.75541D-01   0.39788D-02   0.86141D-01   0.10254D-02   0.14126D-01
RCS Jet #8    (+X)                  28    -0.35434D-02   0.47146D-01   0.39557D-02   0.86141D-01   0.10254D-02   0.14126D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.44284D-02   0.85313D-01   0.65868D-02   0.86126D-01   0.10264D-02   0.14099D-01
Reaction Wheel #2 Spin Axis         18     0.62711D-02   0.10146D+00  -0.59962D-01   0.86130D-01   0.10281D-02   0.14099D-01
Reaction Wheel #3 Spin Axis         19    -0.13055D-01   0.10265D+00   0.58039D-01   0.86129D-01   0.10235D-02   0.14100D-01
Cryo Cooler Pump                     8     0.25915D-01  -0.31445D+00  -0.14966D+00   0.86155D-01   0.10267D-02   0.14105D-01
Cryo Cooler Pump                     8     0.25915D-01  -0.31445D+00  -0.14966D+00   0.86155D-01   0.10267D-02   0.14105D-01
Cryo Cooler Pump                     8     0.25915D-01  -0.31445D+00  -0.14966D+00   0.86155D-01   0.10267D-02   0.14105D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.87972D-02  -0.24124D+00   0.57048D-01   0.86129D-01   0.10269D-02   0.14100D-01
Accelerometers                       7    -0.87972D-02  -0.24124D+00   0.57048D-01   0.86129D-01   0.10269D-02   0.14100D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors            6    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors            6    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors            6    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors            6    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors            6    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Second Mirror                        9     0.26875D-01  -0.41715D+00  -0.14804D+00   0.86155D-01   0.10265D-02   0.14105D-01
Second Mirror                        9     0.26875D-01  -0.41715D+00  -0.14804D+00   0.86155D-01   0.10265D-02   0.14105D-01
Sensitive Instrument 2              10    -0.22926D-01  -0.31125D+00   0.14845D+00   0.86134D-01   0.10275D-02   0.14101D-01
Sensitive Instrument 2              10    -0.22926D-01  -0.31125D+00   0.14845D+00   0.86134D-01   0.10275D-02   0.14101D-01
Sensitive Instrument 3              11    -0.79429D-02  -0.31306D+00   0.57058D-01   0.86130D-01   0.10266D-02   0.14101D-01
Sensitive Instrument 4              12    -0.11534D-01  -0.31139D+00   0.78872D-01   0.86131D-01   0.10267D-02   0.14101D-01
Sensitive Instrument 5              13    -0.11679D-01  -0.30009D+00   0.78938D-01   0.86131D-01   0.10267D-02   0.14101D-01

MODE#  4/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.2672       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.26924D-01  -0.79058D+00   0.75671D-02  -0.10293D-01   0.29830D-02   0.32107D+00
RCS Jet #2    (+X)                  22    -0.72326D-02  -0.72296D+00   0.75694D-02  -0.10243D-01   0.29848D-02   0.32118D+00
RCS Jet #3    (+Y)                  23     0.45368D+00   0.44559D+00   0.11439D-01  -0.10256D-01   0.30264D-02   0.32118D+00
RCS Jet #4    (-Y)                  24    -0.46738D+00   0.44559D+00  -0.17984D-01  -0.10257D-01   0.29428D-02   0.32118D+00
RCS Jet #5    (-Y)                  25    -0.23475D+00  -0.53829D+00  -0.14007D-02  -0.10241D-01   0.29953D-02   0.32122D+00
RCS Jet #6    (+Y)                  26     0.22028D+00  -0.53828D+00   0.13107D-01  -0.10241D-01   0.29740D-02   0.32119D+00
RCS Jet #7    (+X)                  27    -0.16859D-01  -0.75606D+00   0.75646D-02  -0.10204D-01   0.29785D-02   0.32124D+00
RCS Jet #8    (+X)                  28    -0.15866D-01  -0.74543D+00   0.74976D-02  -0.10204D-01   0.29785D-02   0.32124D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.32170D-01  -0.24993D+00   0.23797D-02  -0.10256D-01   0.29845D-02   0.32126D+00
Reaction Wheel #2 Spin Axis         18     0.21166D+00   0.11787D+00   0.67599D-02  -0.10283D-01   0.30016D-02   0.32126D+00
Reaction Wheel #3 Spin Axis         19    -0.22877D+00   0.14513D+00  -0.75771D-02  -0.10283D-01   0.29647D-02   0.32126D+00
Cryo Cooler Pump                     8     0.56190D+00   0.64229D-01   0.18477D-01  -0.10287D-01   0.30532D-02   0.32131D+00
Cryo Cooler Pump                     8     0.56190D+00   0.64229D-01   0.18477D-01  -0.10287D-01   0.30532D-02   0.32131D+00
Cryo Cooler Pump                     8     0.56190D+00   0.64229D-01   0.18477D-01  -0.10287D-01   0.30532D-02   0.32131D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.21288D+00   0.15392D+00  -0.71526D-02  -0.10276D-01   0.29814D-02   0.32131D+00
Accelerometers                       7    -0.21288D+00   0.15392D+00  -0.71526D-02  -0.10276D-01   0.29814D-02   0.32131D+00

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors            6    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors            6    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors            6    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors            6    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors            6    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Second Mirror                        9     0.55952D+00   0.76495D-01   0.18284D-01  -0.10289D-01   0.30550D-02   0.32131D+00
Second Mirror                        9     0.55952D+00   0.76495D-01   0.18284D-01  -0.10289D-01   0.30550D-02   0.32131D+00
Sensitive Instrument 2              10    -0.54946D+00  -0.26946D-01  -0.16240D-01  -0.10277D-01   0.29809D-02   0.32131D+00
Sensitive Instrument 2              10    -0.54946D+00  -0.26946D-01  -0.16240D-01  -0.10277D-01   0.29809D-02   0.32131D+00
Sensitive Instrument 3              11    -0.21025D+00   0.14557D+00  -0.69930D-02  -0.10276D-01   0.29844D-02   0.32131D+00
Sensitive Instrument 4              12    -0.29208D+00   0.18356D+00  -0.99629D-02  -0.10276D-01   0.29842D-02   0.32131D+00
Sensitive Instrument 5              13    -0.29251D+00   0.16148D+00  -0.97714D-02  -0.10276D-01   0.29842D-02   0.32131D+00

MODE#  5/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    25.288       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.16681D-02  -0.17248D+00   0.42082D-03  -0.20857D-02   0.14659D-03   0.69732D-01
RCS Jet #2    (+X)                  22    -0.68348D-03  -0.15987D+00   0.43187D-03  -0.19110D-02   0.15367D-03   0.70177D-01
RCS Jet #3    (+Y)                  23     0.10051D+00   0.96306D-01   0.27211D-02  -0.19507D-02   0.30816D-03   0.70162D-01
RCS Jet #4    (-Y)                  24    -0.10183D+00   0.96307D-01  -0.29485D-02  -0.19535D-02  -0.31482D-05   0.70164D-01
RCS Jet #5    (-Y)                  25    -0.50421D-01  -0.11954D+00  -0.99833D-03  -0.18950D-02   0.19234D-03   0.70270D-01
RCS Jet #6    (+Y)                  26     0.49034D-01  -0.11953D+00   0.16859D-02  -0.18962D-02   0.11494D-03   0.70212D-01
RCS Jet #7    (+X)                  27    -0.11785D-02  -0.16666D+00   0.41615D-03  -0.12286D-02   0.13488D-03   0.71660D-01
RCS Jet #8    (+X)                  28    -0.11335D-02  -0.16463D+00   0.41312D-03  -0.12286D-02   0.13487D-03   0.71660D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.46080D-02  -0.55362D-01   0.10013D-03  -0.19522D-02   0.15138D-03   0.70452D-01
Reaction Wheel #2 Spin Axis         18     0.48816D-01   0.25193D-01   0.14553D-02  -0.20471D-02   0.21338D-03   0.70475D-01
Reaction Wheel #3 Spin Axis         19    -0.47660D-01   0.31177D-01  -0.13128D-02  -0.20461D-02   0.81934D-04   0.70471D-01
Cryo Cooler Pump                     8     0.12387D+00   0.12398D-01   0.36934D-02  -0.20558D-02   0.39721D-03   0.70625D-01
Cryo Cooler Pump                     8     0.12387D+00   0.12398D-01   0.36934D-02  -0.20558D-02   0.39721D-03   0.70625D-01
Cryo Cooler Pump                     8     0.12387D+00   0.12398D-01   0.36934D-02  -0.20558D-02   0.39721D-03   0.70625D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.46334D-01   0.32256D-01  -0.12864D-02  -0.20224D-02   0.14020D-03   0.70624D-01
Accelerometers                       7    -0.46334D-01   0.32256D-01  -0.12864D-02  -0.20224D-02   0.14020D-03   0.70624D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors            6    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors            6    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors            6    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors            6    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors            6    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Second Mirror                        9     0.12303D+00   0.14862D-01   0.36553D-02  -0.20641D-02   0.40378D-03   0.70621D-01
Second Mirror                        9     0.12303D+00   0.14862D-01   0.36553D-02  -0.20641D-02   0.40378D-03   0.70621D-01
Sensitive Instrument 2              10    -0.12070D+00  -0.76748D-02  -0.33406D-02  -0.20252D-02   0.13884D-03   0.70637D-01
Sensitive Instrument 2              10    -0.12070D+00  -0.76748D-02  -0.33406D-02  -0.20252D-02   0.13884D-03   0.70637D-01
Sensitive Instrument 3              11    -0.46179D-01   0.30223D-01  -0.12847D-02  -0.20221D-02   0.15114D-03   0.70639D-01
Sensitive Instrument 4              12    -0.64169D-01   0.38576D-01  -0.18175D-02  -0.20228D-02   0.15005D-03   0.70639D-01
Sensitive Instrument 5              13    -0.64191D-01   0.33756D-01  -0.18079D-02  -0.20228D-02   0.14999D-03   0.70639D-01

MODE#  6/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    25.559       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.19970D+00   0.38839D-03  -0.66600D-01   0.28451D-03  -0.28823D-01   0.62411D-03
RCS Jet #2    (+X)                  22     0.91707D-02  -0.13349D-02  -0.66706D-01   0.25889D-03  -0.28904D-01   0.56374D-03
RCS Jet #3    (+Y)                  23     0.62956D-02   0.68477D-03   0.37932D-01   0.24868D-03  -0.28936D-01   0.56555D-03
RCS Jet #4    (-Y)                  24     0.46800D-02   0.68024D-03   0.38682D-01   0.27564D-03  -0.28949D-01   0.57470D-03
RCS Jet #5    (-Y)                  25     0.88332D-02  -0.98777D-03  -0.49902D-01   0.25860D-03  -0.28900D-01   0.38344D-03
RCS Jet #6    (+Y)                  26     0.96292D-02  -0.10321D-02  -0.50268D-01   0.25751D-03  -0.28896D-01   0.73546D-03
RCS Jet #7    (+X)                  27     0.10243D+00  -0.49014D-03  -0.66623D-01   0.24964D-03  -0.28802D-01   0.54454D-03
RCS Jet #8    (+X)                  28     0.92830D-01  -0.56110D-03  -0.65975D-01   0.24964D-03  -0.28802D-01   0.54454D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.98298D-01   0.36215D-03  -0.21357D-01   0.24293D-03  -0.28932D-01   0.53131D-03
Reaction Wheel #2 Spin Axis         18     0.98696D-01   0.97114D-03   0.11629D-01   0.21346D-03  -0.28867D-01   0.67188D-03
Reaction Wheel #3 Spin Axis         19     0.97907D-01   0.10795D-02   0.14438D-01   0.30145D-03  -0.28884D-01   0.49955D-03
Cryo Cooler Pump                     8    -0.39111D-01  -0.44437D-03   0.20253D-02   0.26365D-03  -0.29137D-01   0.62756D-03
Cryo Cooler Pump                     8    -0.39111D-01  -0.44437D-03   0.20253D-02   0.26365D-03  -0.29137D-01   0.62756D-03
Cryo Cooler Pump                     8    -0.39111D-01  -0.44437D-03   0.20253D-02   0.26365D-03  -0.29137D-01   0.62756D-03

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.17098D-01  -0.44146D-04   0.11525D-01   0.25598D-03  -0.28937D-01   0.56135D-03
Accelerometers                       7    -0.17098D-01  -0.44146D-04   0.11525D-01   0.25598D-03  -0.28937D-01   0.56135D-03

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors            6    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors            6    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors            6    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors            6    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors            6    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Second Mirror                        9    -0.73861D-01  -0.76574D-03   0.20298D-02   0.27101D-03  -0.29141D-01   0.63419D-03
Second Mirror                        9    -0.73861D-01  -0.76574D-03   0.20298D-02   0.27101D-03  -0.29141D-01   0.63419D-03
Sensitive Instrument 2              10    -0.38440D-01  -0.55524D-03  -0.51619D-02   0.25367D-03  -0.28939D-01   0.55519D-03
Sensitive Instrument 2              10    -0.38440D-01  -0.55524D-03  -0.51619D-02   0.25367D-03  -0.28939D-01   0.55519D-03
Sensitive Instrument 3              11    -0.40982D-01  -0.28504D-03   0.10005D-01   0.25553D-03  -0.28933D-01   0.56026D-03
Sensitive Instrument 4              12    -0.41125D-01  -0.21876D-03   0.13491D-01   0.25529D-03  -0.28934D-01   0.55993D-03
Sensitive Instrument 5              13    -0.37026D-01  -0.21852D-03   0.11634D-01   0.25529D-03  -0.28934D-01   0.55993D-03

MODE#  7/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    26.219       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.16640D-01   0.48240D-02  -0.53424D-02  -0.30677D-02  -0.23237D-02  -0.10532D-01
RCS Jet #2    (+X)                  22     0.12686D-02   0.23572D-01  -0.53514D-02  -0.28088D-02  -0.23321D-02  -0.99334D-02
RCS Jet #3    (+Y)                  23    -0.13353D-01  -0.12349D-01   0.71837D-02  -0.28412D-02  -0.24355D-02  -0.99779D-02
RCS Jet #4    (-Y)                  24     0.15295D-01  -0.12349D-01  -0.94127D-03  -0.28394D-02  -0.22339D-02  -0.99773D-02
RCS Jet #5    (-Y)                  25     0.83148D-02   0.17863D-01  -0.59994D-02  -0.28084D-02  -0.23286D-02  -0.99622D-02
RCS Jet #6    (+Y)                  26    -0.57657D-02   0.17859D-01  -0.20213D-02  -0.28085D-02  -0.23345D-02  -0.99272D-02
RCS Jet #7    (+X)                  27     0.87937D-02   0.14492D-01  -0.53416D-02  -0.28777D-02  -0.23194D-02  -0.99806D-02
RCS Jet #8    (+X)                  28     0.80206D-02   0.15227D-01  -0.52894D-02  -0.28777D-02  -0.23194D-02  -0.99806D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.89519D-02  -0.80893D-03  -0.18316D-02  -0.28091D-02  -0.23354D-02  -0.99829D-02
Reaction Wheel #2 Spin Axis         18     0.13739D-02  -0.12243D-01   0.29818D-02  -0.28109D-02  -0.23384D-02  -0.99868D-02
Reaction Wheel #3 Spin Axis         19     0.15053D-01  -0.13086D-01  -0.67873D-03  -0.28015D-02  -0.23184D-02  -0.10005D-01
Cryo Cooler Pump                     8    -0.20314D-01   0.44492D-02   0.51592D-02  -0.28328D-02  -0.23878D-02  -0.10003D-01
Cryo Cooler Pump                     8    -0.20314D-01   0.44492D-02   0.51592D-02  -0.28328D-02  -0.23878D-02  -0.10003D-01
Cryo Cooler Pump                     8    -0.20314D-01   0.44492D-02   0.51592D-02  -0.28328D-02  -0.23878D-02  -0.10003D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.56641D-02  -0.87357D-03  -0.87643D-03  -0.28129D-02  -0.23332D-02  -0.10004D-01
Accelerometers                       7     0.56641D-02  -0.87357D-03  -0.87643D-03  -0.28129D-02  -0.23332D-02  -0.10004D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors            6     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors            6     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors            6     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors            6     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors            6     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Second Mirror                        9    -0.22975D-01   0.78272D-02   0.51060D-02  -0.28308D-02  -0.23888D-02  -0.10002D-01
Second Mirror                        9    -0.22975D-01   0.78272D-02   0.51060D-02  -0.28308D-02  -0.23888D-02  -0.10002D-01
Sensitive Instrument 2              10     0.14540D-01   0.70092D-02  -0.52113D-02  -0.28171D-02  -0.23335D-02  -0.10007D-01
Sensitive Instrument 2              10     0.14540D-01   0.70092D-02  -0.52113D-02  -0.28171D-02  -0.23335D-02  -0.10007D-01
Sensitive Instrument 3              11     0.37331D-02   0.19753D-02  -0.99659D-03  -0.28148D-02  -0.23339D-02  -0.10007D-01
Sensitive Instrument 4              12     0.62815D-02   0.79214D-03  -0.14375D-02  -0.28150D-02  -0.23340D-02  -0.10007D-01
Sensitive Instrument 5              13     0.66121D-02   0.10355D-02  -0.15873D-02  -0.28150D-02  -0.23340D-02  -0.10007D-01

MODE#  8/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    27.119       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.13290D+00   0.62625D-02   0.59186D-01   0.11409D-03   0.23908D-01  -0.24126D-02
RCS Jet #2    (+X)                  22     0.25592D-01   0.55570D-02   0.59510D-01   0.10425D-03   0.24095D-01  -0.24451D-02
RCS Jet #3    (+Y)                  23     0.25190D-01  -0.33432D-02  -0.28010D-01   0.14120D-03   0.24146D-01  -0.24719D-02
RCS Jet #4    (-Y)                  24     0.32196D-01  -0.33089D-02  -0.27699D-01   0.75294D-04   0.24143D-01  -0.23999D-02
RCS Jet #5    (-Y)                  25     0.27215D-01   0.41098D-02   0.45734D-01   0.11404D-03   0.24094D-01  -0.21277D-02
RCS Jet #6    (+Y)                  26     0.23749D-01   0.41934D-02   0.45587D-01   0.93097D-04   0.24096D-01  -0.27695D-02
RCS Jet #7    (+X)                  27    -0.52058D-01   0.59266D-02   0.59417D-01   0.84799D-04   0.24044D-01  -0.24991D-02
RCS Jet #8    (+X)                  28    -0.44043D-01   0.58421D-02   0.58876D-01   0.84800D-04   0.24044D-01  -0.24991D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.48516D-01   0.20546D-02   0.21787D-01   0.11673D-03   0.24078D-01  -0.24232D-02
Reaction Wheel #2 Spin Axis         18    -0.50335D-01  -0.71844D-03  -0.58769D-02   0.13861D-03   0.24016D-01  -0.24983D-02
Reaction Wheel #3 Spin Axis         19    -0.46979D-01  -0.96054D-03  -0.77684D-02   0.80951D-04   0.24030D-01  -0.24136D-02
Cryo Cooler Pump                     8     0.62500D-01  -0.46098D-03   0.18039D-02   0.11901D-03   0.24362D-01  -0.25459D-02
Cryo Cooler Pump                     8     0.62500D-01  -0.46098D-03   0.18039D-02   0.11901D-03   0.24362D-01  -0.25459D-02
Cryo Cooler Pump                     8     0.62500D-01  -0.46098D-03   0.18039D-02   0.11901D-03   0.24362D-01  -0.25459D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.48777D-01  -0.11389D-02  -0.53552D-02   0.11529D-03   0.24074D-01  -0.24412D-02
Accelerometers                       7     0.48777D-01  -0.11389D-02  -0.53552D-02   0.11529D-03   0.24074D-01  -0.24412D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors            6     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors            6     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors            6     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors            6     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors            6     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Second Mirror                        9     0.91598D-01  -0.59333D-03   0.18067D-02   0.10899D-03   0.24368D-01  -0.25546D-02
Second Mirror                        9     0.91598D-01  -0.59333D-03   0.18067D-02   0.10899D-03   0.24368D-01  -0.25546D-02
Sensitive Instrument 2              10     0.68620D-01   0.20720D-03   0.88765D-02   0.11870D-03   0.24077D-01  -0.24296D-02
Sensitive Instrument 2              10     0.68620D-01   0.20720D-03   0.88765D-02   0.11870D-03   0.24077D-01  -0.24296D-02
Sensitive Instrument 3              11     0.68652D-01  -0.11045D-02  -0.40861D-02   0.11439D-03   0.24067D-01  -0.24398D-02
Sensitive Instrument 4              12     0.69274D-01  -0.13931D-02  -0.69027D-02   0.11490D-03   0.24068D-01  -0.24392D-02
Sensitive Instrument 5              13     0.65864D-01  -0.12203D-02  -0.53583D-02   0.11490D-03   0.24068D-01  -0.24392D-02

MODE#  9/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    88.716       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.21039D-03   0.77563D-01  -0.64330D-03   0.21202D-01  -0.21230D-03   0.31006D-01
RCS Jet #2    (+X)                  22    -0.11125D-02  -0.69110D-01  -0.61890D-03   0.22788D-01  -0.17590D-03   0.33865D-01
RCS Jet #3    (+Y)                  23     0.51252D-01   0.56895D-01  -0.31590D-01   0.22284D-01   0.29645D-03   0.33671D-01
RCS Jet #4    (-Y)                  24    -0.53471D-01   0.56898D-01   0.31817D-01   0.22290D-01  -0.77720D-03   0.33724D-01
RCS Jet #5    (-Y)                  25    -0.25445D-01  -0.49811D-01   0.15733D-01   0.22949D-01   0.14082D-03   0.34950D-01
RCS Jet #6    (+Y)                  26     0.22999D-01  -0.49733D-01  -0.16764D-01   0.22934D-01  -0.49568D-03   0.34312D-01
RCS Jet #7    (+X)                  27    -0.53535D-03   0.37250D-02  -0.80246D-03   0.21733D-01  -0.43285D-03   0.33920D-01
RCS Jet #8    (+X)                  28    -0.67963D-03  -0.27562D-02  -0.79272D-03   0.21733D-01  -0.43284D-03   0.33920D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.22416D-02   0.55112D-01   0.73581D-03   0.21901D-01  -0.15918D-03   0.34348D-01
Reaction Wheel #2 Spin Axis         18     0.24143D-01   0.95439D-01  -0.16302D-01   0.22074D-01   0.54644D-03   0.36090D-01
Reaction Wheel #3 Spin Axis         19    -0.23369D-01   0.98598D-01   0.15123D-01   0.21912D-01  -0.12389D-02   0.36518D-01
Cryo Cooler Pump                     8     0.64915D-01  -0.23617D-01  -0.39111D-01   0.23794D-01   0.11921D-02   0.36918D-01
Cryo Cooler Pump                     8     0.64915D-01  -0.23617D-01  -0.39111D-01   0.23794D-01   0.11921D-02   0.36918D-01
Cryo Cooler Pump                     8     0.64915D-01  -0.23617D-01  -0.39111D-01   0.23794D-01   0.11921D-02   0.36918D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.25054D-01   0.72141D-02   0.14411D-01   0.22358D-01  -0.20425D-03   0.36709D-01
Accelerometers                       7    -0.25054D-01   0.72141D-02   0.14411D-01   0.22358D-01  -0.20425D-03   0.36709D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors            6    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors            6    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors            6    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors            6    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors            6    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Second Mirror                        9     0.65699D-01  -0.52141D-01  -0.38664D-01   0.23704D-01   0.12194D-02   0.36884D-01
Second Mirror                        9     0.65699D-01  -0.52141D-01  -0.38664D-01   0.23704D-01   0.12194D-02   0.36884D-01
Sensitive Instrument 2              10    -0.63998D-01  -0.30502D-01   0.37983D-01   0.22523D-01  -0.13476D-03   0.36792D-01
Sensitive Instrument 2              10    -0.63998D-01  -0.30502D-01   0.37983D-01   0.22523D-01  -0.13476D-03   0.36792D-01
Sensitive Instrument 3              11    -0.25192D-01  -0.13239D-01   0.14369D-01   0.22387D-01  -0.13333D-03   0.36788D-01
Sensitive Instrument 4              12    -0.34561D-01  -0.88888D-02   0.20086D-01   0.22391D-01  -0.12686D-03   0.36786D-01
Sensitive Instrument 5              13    -0.34544D-01  -0.80771D-02   0.20077D-01   0.22391D-01  -0.12712D-03   0.36786D-01

MODE# 10/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    89.868       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.17765D-02  -0.22355D+00  -0.18423D-02  -0.18139D-01  -0.46505D-03   0.38178D-01
RCS Jet #2    (+X)                  22    -0.13877D-02  -0.11247D+00  -0.18354D-02  -0.17344D-01  -0.46164D-03   0.40025D-01
RCS Jet #3    (+Y)                  23     0.60790D-01   0.43888D-01   0.25214D-01  -0.17417D-01   0.15128D-02   0.40631D-01
RCS Jet #4    (-Y)                  24    -0.63680D-01   0.43887D-01  -0.25447D-01  -0.17431D-01  -0.24101D-02   0.40591D-01
RCS Jet #5    (-Y)                  25    -0.29775D-01  -0.89503D-01  -0.13787D-01  -0.17264D-01  -0.21581D-03   0.40195D-01
RCS Jet #6    (+Y)                  26     0.27021D-01  -0.89508D-01   0.10648D-01  -0.17261D-01  -0.70338D-03   0.40252D-01
RCS Jet #7    (+X)                  27     0.81901D-04  -0.17629D+00  -0.18856D-02  -0.68490D-02  -0.51857D-03   0.60833D-01
RCS Jet #8    (+X)                  28    -0.90937D-04  -0.17264D+00  -0.18739D-02  -0.68495D-02  -0.51857D-03   0.60834D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.20961D-02  -0.10114D+00  -0.19367D-02  -0.17227D-01  -0.52034D-03   0.43510D-01
Reaction Wheel #2 Spin Axis         18     0.29986D-01  -0.53534D-01   0.12807D-01  -0.18540D-01  -0.28504D-03   0.42289D-01
Reaction Wheel #3 Spin Axis         19    -0.27785D-01  -0.49983D-01  -0.12921D-01  -0.18398D-01  -0.46790D-03   0.41876D-01
Cryo Cooler Pump                     8     0.77558D-01   0.21935D-01   0.32439D-01  -0.19728D-01   0.17453D-02   0.43685D-01
Cryo Cooler Pump                     8     0.77558D-01   0.21935D-01   0.32439D-01  -0.19728D-01   0.17453D-02   0.43685D-01
Cryo Cooler Pump                     8     0.77558D-01   0.21935D-01   0.32439D-01  -0.19728D-01   0.17453D-02   0.43685D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.30232D-01   0.18919D-01  -0.12567D-01  -0.18478D-01  -0.60346D-03   0.43806D-01
Accelerometers                       7    -0.30232D-01   0.18919D-01  -0.12567D-01  -0.18478D-01  -0.60346D-03   0.43806D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors            6    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors            6    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors            6    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors            6    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors            6    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Second Mirror                        9     0.78923D-01   0.45708D-01   0.32075D-01  -0.19765D-01   0.18072D-02   0.43656D-01
Second Mirror                        9     0.78923D-01   0.45708D-01   0.32075D-01  -0.19765D-01   0.18072D-02   0.43656D-01
Sensitive Instrument 2              10    -0.77003D-01   0.64842D-02  -0.32525D-01  -0.18586D-01  -0.67285D-03   0.43920D-01
Sensitive Instrument 2              10    -0.77003D-01   0.64842D-02  -0.32525D-01  -0.18586D-01  -0.67285D-03   0.43920D-01
Sensitive Instrument 3              11    -0.30677D-01   0.31875D-01  -0.12666D-01  -0.18473D-01  -0.52142D-03   0.43964D-01
Sensitive Instrument 4              12    -0.41875D-01   0.37074D-01  -0.17307D-01  -0.18484D-01  -0.53934D-03   0.43961D-01
Sensitive Instrument 5              13    -0.41798D-01   0.31634D-01  -0.17342D-01  -0.18484D-01  -0.53980D-03   0.43961D-01

MODE# 11/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    91.715       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.27027D+00   0.11279D-03  -0.90416D-01   0.27529D-03  -0.39298D-01   0.82211D-03
RCS Jet #2    (+X)                  22     0.38579D-02  -0.15863D-02  -0.93122D-01   0.28092D-03  -0.41195D-01   0.82524D-03
RCS Jet #3    (+Y)                  23    -0.54246D-03   0.12368D-02   0.55481D-01  -0.55414D-04  -0.42026D-01   0.88664D-03
RCS Jet #4    (-Y)                  24    -0.26957D-02   0.10507D-02   0.56257D-01   0.60136D-03  -0.41940D-01   0.80708D-03
RCS Jet #5    (-Y)                  25     0.46106D-02  -0.61344D-03  -0.69248D-01   0.24364D-03  -0.41125D-01  -0.30755D-02
RCS Jet #6    (+Y)                  26     0.57347D-02  -0.15875D-02  -0.69632D-01   0.29940D-03  -0.41081D-01   0.45851D-02
RCS Jet #7    (+X)                  27     0.13719D+00  -0.66166D-03  -0.91532D-01   0.89498D-04  -0.39470D-01   0.62692D-03
RCS Jet #8    (+X)                  28     0.12404D+00  -0.67738D-03  -0.90643D-01   0.89503D-04  -0.39469D-01   0.62689D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.13213D+00   0.58175D-03  -0.29885D-01  -0.11681D-04  -0.41525D-01   0.18125D-03
Reaction Wheel #2 Spin Axis         18     0.13219D+00   0.78855D-03   0.18459D-01  -0.58396D-03  -0.40364D-01   0.26665D-02
Reaction Wheel #3 Spin Axis         19     0.13085D+00   0.19458D-02   0.22314D-01   0.10526D-02  -0.40688D-01  -0.34390D-03
Cryo Cooler Pump                     8    -0.70798D-01  -0.66441D-03   0.32398D-02   0.34222D-03  -0.46088D-01   0.22061D-02
Cryo Cooler Pump                     8    -0.70798D-01  -0.66441D-03   0.32398D-02   0.34222D-03  -0.46088D-01   0.22061D-02
Cryo Cooler Pump                     8    -0.70798D-01  -0.66441D-03   0.32398D-02   0.34222D-03  -0.46088D-01   0.22061D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.34163D-01   0.22891D-03   0.17831D-01   0.19504D-03  -0.41629D-01   0.69202D-03
Accelerometers                       7    -0.34163D-01   0.22891D-03   0.17831D-01   0.19504D-03  -0.41629D-01   0.69202D-03

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors            6    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors            6    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors            6    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors            6    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors            6    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Second Mirror                        9    -0.12592D+00  -0.12280D-02   0.32379D-02   0.50467D-03  -0.46156D-01   0.23500D-02
Second Mirror                        9    -0.12592D+00  -0.12280D-02   0.32379D-02   0.50467D-03  -0.46156D-01   0.23500D-02
Sensitive Instrument 2              10    -0.64852D-01  -0.28183D-03  -0.64459D-02   0.13784D-03  -0.41678D-01   0.55166D-03
Sensitive Instrument 2              10    -0.64852D-01  -0.28183D-03  -0.64459D-02   0.13784D-03  -0.41678D-01   0.55166D-03
Sensitive Instrument 3              11    -0.68629D-01   0.29837D-04   0.15572D-01   0.18402D-03  -0.41568D-01   0.66398D-03
Sensitive Instrument 4              12    -0.68799D-01   0.10923D-03   0.20534D-01   0.17878D-03  -0.41575D-01   0.65756D-03
Sensitive Instrument 5              13    -0.62909D-01   0.92360D-04   0.17866D-01   0.17878D-03  -0.41575D-01   0.65756D-03

MODE# 12/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    121.96       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.37063D-03   0.64902D-01   0.16366D-03   0.73777D-02  -0.21524D-04  -0.49015D-02
RCS Jet #2    (+X)                  22     0.20403D-03   0.12745D-01   0.14943D-03   0.84366D-02  -0.27728D-04  -0.34820D-02
RCS Jet #3    (+Y)                  23    -0.55048D-02  -0.26063D-02  -0.11495D-01   0.81652D-02  -0.85232D-03  -0.36305D-02
RCS Jet #4    (-Y)                  24     0.59220D-02  -0.26053D-02   0.12031D-01   0.81791D-02   0.72128D-03  -0.35875D-02
RCS Jet #5    (-Y)                  25     0.25752D-02   0.10702D-01   0.61591D-02   0.84694D-02   0.80026D-05  -0.31966D-02
RCS Jet #6    (+Y)                  26    -0.22365D-02   0.10725D-01  -0.58263D-02   0.84631D-02  -0.64781D-04  -0.33944D-02
RCS Jet #7    (+X)                  27     0.30740D-03   0.42866D-01   0.11314D-03   0.34818D-02  -0.88332D-04  -0.12104D-01
RCS Jet #8    (+X)                  28     0.27796D-03   0.41434D-01   0.11513D-03   0.34820D-02  -0.88313D-04  -0.12106D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.53421D-03   0.32549D-01   0.57343D-03   0.80202D-02   0.99240D-06  -0.47644D-02
Reaction Wheel #2 Spin Axis         18    -0.25770D-02   0.28356D-01  -0.61599D-02   0.86392D-02   0.13885D-03  -0.36673D-02
Reaction Wheel #3 Spin Axis         19     0.30156D-02   0.28099D-01   0.62099D-02   0.85363D-02  -0.38015D-03  -0.33694D-02
Cryo Cooler Pump                     8    -0.77766D-02  -0.13102D-01  -0.15304D-01   0.10072D-01  -0.62443D-03  -0.39191D-02
Cryo Cooler Pump                     8    -0.77766D-02  -0.13102D-01  -0.15304D-01   0.10072D-01  -0.62443D-03  -0.39191D-02
Cryo Cooler Pump                     8    -0.77766D-02  -0.13102D-01  -0.15304D-01   0.10072D-01  -0.62443D-03  -0.39191D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.28613D-02  -0.56914D-02   0.58974D-02   0.87098D-02   0.24538D-04  -0.41132D-02
Accelerometers                       7     0.28613D-02  -0.56914D-02   0.58974D-02   0.87098D-02   0.24538D-04  -0.41132D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors            6     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors            6     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors            6     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors            6     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors            6     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Second Mirror                        9    -0.84807D-02  -0.25319D-01  -0.15117D-01   0.10061D-01  -0.64633D-03  -0.39161D-02
Second Mirror                        9    -0.84807D-02  -0.25319D-01  -0.15117D-01   0.10061D-01  -0.64633D-03  -0.39161D-02
Sensitive Instrument 2              10     0.72480D-02  -0.96081D-02   0.15204D-01   0.88381D-02   0.83161D-04  -0.41339D-02
Sensitive Instrument 2              10     0.72480D-02  -0.96081D-02   0.15204D-01   0.88381D-02   0.83161D-04  -0.41339D-02
Sensitive Instrument 3              11     0.28679D-02  -0.12711D-01   0.59230D-02   0.87236D-02   0.10587D-04  -0.41551D-02
Sensitive Instrument 4              12     0.39267D-02  -0.13202D-01   0.81421D-02   0.87300D-02   0.21695D-04  -0.41543D-02
Sensitive Instrument 5              13     0.39236D-02  -0.11699D-01   0.81435D-02   0.87301D-02   0.21818D-04  -0.41544D-02

MODE# 13/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    127.18       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.80292D-01   0.77124D-02   0.89362D-01   0.79555D-03   0.11352D-01  -0.93814D-03
RCS Jet #2    (+X)                  22     0.90535D-03   0.21048D-02   0.92667D-01   0.85505D-03   0.12134D-01  -0.10211D-02
RCS Jet #3    (+Y)                  23     0.10222D-02  -0.15966D-02   0.45790D-01   0.11098D-02   0.13399D-01  -0.11485D-02
RCS Jet #4    (-Y)                  24     0.38850D-02  -0.14546D-02   0.48290D-01   0.64968D-03   0.13336D-01  -0.71315D-03
RCS Jet #5    (-Y)                  25    -0.68504D-03   0.67441D-03   0.86230D-01   0.73784D-03   0.11832D-01   0.56963D-02
RCS Jet #6    (+Y)                  26    -0.20692D-02   0.23338D-02   0.85008D-01   0.98867D-03   0.11799D-01  -0.75502D-02
RCS Jet #7    (+X)                  27    -0.40694D-01   0.52861D-02   0.92774D-01   0.55226D-03   0.13247D-01  -0.18197D-02
RCS Jet #8    (+X)                  28    -0.36281D-01   0.50611D-02   0.92474D-01   0.55229D-03   0.13242D-01  -0.18198D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.40599D-01   0.32282D-02   0.75273D-01   0.11818D-02   0.15170D-01  -0.39912D-03
Reaction Wheel #2 Spin Axis         18    -0.39035D-01   0.16062D-02   0.59028D-01  -0.46906D-03   0.11587D-01  -0.15628D-02
Reaction Wheel #3 Spin Axis         19    -0.37629D-01   0.29346D-02   0.59216D-01   0.21050D-02   0.11412D-01  -0.15114D-03
Cryo Cooler Pump                     8     0.26620D-01  -0.31918D-02   0.64748D-01   0.40403D-02   0.17627D-01  -0.19285D-02
Cryo Cooler Pump                     8     0.26620D-01  -0.31918D-02   0.64748D-01   0.40403D-02   0.17627D-01  -0.19285D-02
Cryo Cooler Pump                     8     0.26620D-01  -0.31918D-02   0.64748D-01   0.40403D-02   0.17627D-01  -0.19285D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.13597D-01  -0.13321D-02   0.61006D-01   0.90301D-03   0.13517D-01  -0.93880D-03
Accelerometers                       7     0.13597D-01  -0.13321D-02   0.61006D-01   0.90301D-03   0.13517D-01  -0.93880D-03

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors            6     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors            6     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors            6     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors            6     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors            6     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Second Mirror                        9     0.47750D-01  -0.78585D-02   0.64856D-01   0.39678D-02   0.17660D-01  -0.20418D-02
Second Mirror                        9     0.47750D-01  -0.78585D-02   0.64856D-01   0.39678D-02   0.17660D-01  -0.20418D-02
Sensitive Instrument 2              10     0.24238D-01  -0.14948D-02   0.70101D-01   0.81956D-03   0.13439D-01  -0.83850D-03
Sensitive Instrument 2              10     0.24238D-01  -0.14948D-02   0.70101D-01   0.81956D-03   0.13439D-01  -0.83850D-03
Sensitive Instrument 3              11     0.24724D-01  -0.20329D-02   0.61862D-01   0.85154D-03   0.13392D-01  -0.91834D-03
Sensitive Instrument 4              12     0.24958D-01  -0.21434D-02   0.60495D-01   0.86575D-03   0.13399D-01  -0.88814D-03
Sensitive Instrument 5              13     0.23060D-01  -0.19638D-02   0.61354D-01   0.86576D-03   0.13400D-01  -0.88811D-03

MODE# 14/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.64       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.99644D-01  -0.31934D-02  -0.29371D-01  -0.40916D-03   0.13966D-01   0.69764D-04
RCS Jet #2    (+X)                  22    -0.41639D-02  -0.40477D-03  -0.29083D-01  -0.42097D-03   0.15782D-01   0.15890D-03
RCS Jet #3    (+Y)                  23    -0.14693D-02   0.34177D-03  -0.83329D-01  -0.23260D-03   0.15679D-01   0.24180D-03
RCS Jet #4    (-Y)                  24    -0.22173D-02   0.44407D-03  -0.84622D-01  -0.68882D-03   0.15659D-01  -0.16037D-03
RCS Jet #5    (-Y)                  25    -0.37863D-02  -0.15088D-03  -0.38370D-01  -0.24352D-03   0.16009D-01  -0.12373D-02
RCS Jet #6    (+Y)                  26    -0.35388D-02  -0.49184D-03  -0.37789D-01  -0.57692D-03   0.15958D-01   0.16330D-02
RCS Jet #7    (+X)                  27    -0.53205D-01  -0.20559D-02  -0.31383D-01  -0.16318D-03   0.12268D-01   0.71996D-03
RCS Jet #8    (+X)                  28    -0.49114D-01  -0.19854D-02  -0.31658D-01  -0.16319D-03   0.12269D-01   0.72004D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.50428D-01  -0.15878D-02  -0.53538D-01  -0.39600D-03   0.13076D-01   0.36977D-03
Reaction Wheel #2 Spin Axis         18    -0.52041D-01   0.15442D-03  -0.71537D-01   0.22307D-02   0.15234D-01  -0.19342D-02
Reaction Wheel #3 Spin Axis         19    -0.51940D-01  -0.28718D-02  -0.73428D-01  -0.28529D-02   0.15850D-01   0.96109D-03
Cryo Cooler Pump                     8     0.25148D-01   0.29592D-02  -0.66292D-01  -0.37822D-02   0.17506D-01  -0.10260D-02
Cryo Cooler Pump                     8     0.25148D-01   0.29592D-02  -0.66292D-01  -0.37822D-02   0.17506D-01  -0.10260D-02
Cryo Cooler Pump                     8     0.25148D-01   0.29592D-02  -0.66292D-01  -0.37822D-02   0.17506D-01  -0.10260D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.95231D-02   0.56438D-03  -0.71972D-01  -0.34591D-03   0.15006D-01   0.28504D-03
Accelerometers                       7     0.95231D-02   0.56438D-03  -0.71972D-01  -0.34591D-03   0.15006D-01   0.28504D-03

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors            6     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors            6     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors            6     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors            6     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors            6     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Second Mirror                        9     0.46159D-01   0.75394D-02  -0.66384D-01  -0.39558D-02   0.17572D-01  -0.11291D-02
Second Mirror                        9     0.46159D-01   0.75394D-02  -0.66384D-01  -0.39558D-02   0.17572D-01  -0.11291D-02
Sensitive Instrument 2              10     0.20180D-01   0.64525D-03  -0.63634D-01  -0.15582D-03   0.15163D-01   0.38179D-03
Sensitive Instrument 2              10     0.20180D-01   0.64525D-03  -0.63634D-01  -0.15582D-03   0.15163D-01   0.38179D-03
Sensitive Instrument 3              11     0.22094D-01   0.82950D-03  -0.71235D-01  -0.26663D-03   0.15052D-01   0.30749D-03
Sensitive Instrument 4              12     0.22018D-01   0.86658D-03  -0.73081D-01  -0.27373D-03   0.15054D-01   0.28453D-03
Sensitive Instrument 5              13     0.19885D-01   0.80957D-03  -0.72115D-01  -0.27374D-03   0.15054D-01   0.28450D-03

MODE# 15/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    139.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.19044D-02  -0.34220D+00   0.37227D-04  -0.46960D-01   0.22470D-03   0.38023D-02
RCS Jet #2    (+X)                  22    -0.14833D-03   0.40969D-02   0.98553D-04  -0.56580D-01   0.20771D-03  -0.10690D-02
RCS Jet #3    (+Y)                  23    -0.57272D-02   0.16787D-02   0.75962D-01  -0.54092D-01   0.24232D-02  -0.44962D-02
RCS Jet #4    (-Y)                  24     0.52686D-02   0.16598D-02  -0.78093D-01  -0.54222D-01  -0.11911D-02  -0.49142D-02
RCS Jet #5    (-Y)                  25     0.16047D-02   0.39698D-02  -0.40400D-01  -0.57059D-01  -0.58458D-03  -0.41690D-02
RCS Jet #6    (+Y)                  26    -0.13242D-02   0.37699D-02   0.40333D-01  -0.56990D-01   0.98974D-03  -0.25121D-02
RCS Jet #7    (+X)                  27    -0.95650D-03  -0.19319D+00   0.69917D-03  -0.27662D-01   0.11117D-02   0.44785D-01
RCS Jet #8    (+X)                  28    -0.58598D-03  -0.18296D+00   0.67412D-03  -0.27664D-01   0.11115D-02   0.44791D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.11118D-02  -0.17137D+00  -0.27342D-02  -0.52259D-01   0.77240D-04   0.34817D-02
Reaction Wheel #2 Spin Axis         18    -0.16670D-02  -0.17600D+00   0.41437D-01  -0.56334D-01  -0.17003D-02  -0.48919D-02
Reaction Wheel #3 Spin Axis         19    -0.75910D-03  -0.17683D+00  -0.40140D-01  -0.55469D-01   0.37687D-02  -0.71756D-02
Cryo Cooler Pump                     8    -0.42998D-02   0.11433D+00   0.10071D+00  -0.71987D-01   0.16441D-02  -0.55270D-02
Cryo Cooler Pump                     8    -0.42998D-02   0.11433D+00   0.10071D+00  -0.71987D-01   0.16441D-02  -0.55270D-02
Cryo Cooler Pump                     8    -0.42998D-02   0.11433D+00   0.10071D+00  -0.71987D-01   0.16441D-02  -0.55270D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.21090D-02   0.49200D-01  -0.37852D-01  -0.57130D-01  -0.30222D-04  -0.33472D-02
Accelerometers                       7     0.21090D-02   0.49200D-01  -0.37852D-01  -0.57130D-01  -0.30222D-04  -0.33472D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors            6     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors            6     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors            6     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors            6     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors            6     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Second Mirror                        9    -0.20748D-02   0.20223D+00   0.99363D-01  -0.71797D-01   0.17687D-02  -0.54815D-02
Second Mirror                        9    -0.20748D-02   0.20223D+00   0.99363D-01  -0.71797D-01   0.17687D-02  -0.54815D-02
Sensitive Instrument 2              10     0.56641D-02   0.93414D-01  -0.99188D-01  -0.58596D-01  -0.52920D-03  -0.34277D-02
Sensitive Instrument 2              10     0.56641D-02   0.93414D-01  -0.99188D-01  -0.58596D-01  -0.52920D-03  -0.34277D-02
Sensitive Instrument 3              11     0.21529D-02   0.97290D-01  -0.37974D-01  -0.57415D-01  -0.70116D-05  -0.32873D-02
Sensitive Instrument 4              12     0.29861D-02   0.96901D-01  -0.52582D-01  -0.57468D-01  -0.98028D-04  -0.32861D-02
Sensitive Instrument 5              13     0.29999D-02   0.88971D-01  -0.52589D-01  -0.57468D-01  -0.98437D-04  -0.32851D-02

MODE# 16/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    179.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.16261D-02  -0.54071D+00  -0.13084D-02  -0.53093D-01  -0.93551D-03   0.50581D-01
RCS Jet #2    (+X)                  22    -0.61782D-02  -0.16121D+00  -0.57485D-03  -0.67322D-01  -0.68129D-03   0.54516D-01
RCS Jet #3    (+Y)                  23     0.10075D+00   0.97523D-01   0.92727D-01  -0.62880D-01   0.15902D-01   0.49038D-01
RCS Jet #4    (-Y)                  24    -0.11374D+00   0.97434D-01  -0.90497D-01  -0.63305D-01  -0.15289D-01   0.47621D-01
RCS Jet #5    (-Y)                  25    -0.44002D-01  -0.12958D+00  -0.47958D-01  -0.67614D-01  -0.59213D-03   0.52262D-01
RCS Jet #6    (+Y)                  26     0.31870D-01  -0.12963D+00   0.47521D-01  -0.67424D-01  -0.86845D-03   0.52854D-01
RCS Jet #7    (+X)                  27    -0.47804D-02  -0.44478D+00  -0.21007D-03   0.40841D-01   0.23621D-03   0.24595D+00
RCS Jet #8    (+X)                  28    -0.47018D-02  -0.45287D+00  -0.21560D-03   0.40837D-01   0.23534D-03   0.24598D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.90183D-02  -0.26638D+00  -0.22111D-02  -0.60487D-01  -0.96779D-03   0.82404D-01
Reaction Wheel #2 Spin Axis         18     0.43354D-01  -0.19611D+00   0.56780D-01  -0.73826D-01  -0.15799D-02   0.64336D-01
Reaction Wheel #3 Spin Axis         19    -0.49951D-01  -0.19122D+00  -0.51006D-01  -0.71734D-01   0.31451D-02   0.59724D-01
Cryo Cooler Pump                     8     0.16051D+00   0.18413D+00   0.13973D+00  -0.11617D+00   0.23850D-01   0.70908D-01
Cryo Cooler Pump                     8     0.16051D+00   0.18413D+00   0.13973D+00  -0.11617D+00   0.23850D-01   0.70908D-01
Cryo Cooler Pump                     8     0.16051D+00   0.18413D+00   0.13973D+00  -0.11617D+00   0.23850D-01   0.70908D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.57745D-01   0.97678D-01  -0.48057D-01  -0.74640D-01  -0.15650D-02   0.78572D-01
Accelerometers                       7    -0.57745D-01   0.97678D-01  -0.48057D-01  -0.74640D-01  -0.15650D-02   0.78572D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors            6    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors            6    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors            6    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors            6    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors            6    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Second Mirror                        9     0.18890D+00   0.32885D+00   0.13759D+00  -0.11640D+00   0.24653D-01   0.70578D-01
Second Mirror                        9     0.18890D+00   0.32885D+00   0.13759D+00  -0.11640D+00   0.24653D-01   0.70578D-01
Sensitive Instrument 2              10    -0.14275D+00   0.10732D+00  -0.13017D+00  -0.77750D-01  -0.27569D-02   0.79259D-01
Sensitive Instrument 2              10    -0.14275D+00   0.10732D+00  -0.13017D+00  -0.77750D-01  -0.27569D-02   0.79259D-01
Sensitive Instrument 3              11    -0.58661D-01   0.15663D+00  -0.48906D-01  -0.75072D-01  -0.88282D-03   0.79777D-01
Sensitive Instrument 4              12    -0.78994D-01   0.16607D+00  -0.67888D-01  -0.75223D-01  -0.11433D-02   0.79754D-01
Sensitive Instrument 5              13    -0.78833D-01   0.15029D+00  -0.67961D-01  -0.75226D-01  -0.11473D-02   0.79757D-01

MODE# 17/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    183.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.18811D+00  -0.23853D-01  -0.71068D-01  -0.20161D-02  -0.24462D-01   0.35854D-02
RCS Jet #2    (+X)                  22     0.37233D-02  -0.84561D-02  -0.80182D-01  -0.27366D-02  -0.29969D-01   0.36589D-02
RCS Jet #3    (+Y)                  23     0.50979D-02   0.62189D-02   0.32209D-01  -0.36427D-02  -0.33233D-01   0.36103D-02
RCS Jet #4    (-Y)                  24    -0.63778D-02   0.56450D-02   0.25006D-01  -0.13315D-02  -0.34026D-01   0.34375D-02
RCS Jet #5    (-Y)                  25     0.67439D-02  -0.42710D-02  -0.64906D-01  -0.28039D-02  -0.29664D-01  -0.12694D-01
RCS Jet #6    (+Y)                  26     0.11567D-01  -0.82551D-02  -0.60923D-01  -0.28223D-02  -0.29345D-01   0.18890D-01
RCS Jet #7    (+X)                  27     0.10338D+00  -0.19859D-01  -0.76393D-01   0.12894D-02  -0.26732D-01   0.11086D-01
RCS Jet #8    (+X)                  28     0.94471D-01  -0.20040D-01  -0.75790D-01   0.12893D-02  -0.26724D-01   0.11087D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.10234D+00  -0.10301D-01  -0.38057D-01  -0.33340D-02  -0.32543D-01   0.24547D-02
Reaction Wheel #2 Spin Axis         18     0.10328D+00  -0.78564D-02   0.37486D-02  -0.48883D-02  -0.27667D-01   0.10093D-01
Reaction Wheel #3 Spin Axis         19     0.96899D-01  -0.50646D-02   0.20213D-02  -0.11517D-02  -0.28446D-01  -0.12043D-03
Cryo Cooler Pump                     8    -0.66392D-01   0.71174D-02  -0.10461D-01  -0.63797D-02  -0.51517D-01   0.10436D-01
Cryo Cooler Pump                     8    -0.66392D-01   0.71174D-02  -0.10461D-01  -0.63797D-02  -0.51517D-01   0.10436D-01
Cryo Cooler Pump                     8    -0.66392D-01   0.71174D-02  -0.10461D-01  -0.63797D-02  -0.51517D-01   0.10436D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.28631D-01   0.48049D-02  -0.20775D-02  -0.31711D-02  -0.32467D-01   0.38623D-02
Accelerometers                       7    -0.28631D-01   0.48049D-02  -0.20775D-02  -0.31711D-02  -0.32467D-01   0.38623D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors            6    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors            6    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors            6    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors            6    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors            6    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Second Mirror                        9    -0.12853D+00   0.14268D-01  -0.10632D-01  -0.56976D-02  -0.51761D-01   0.11068D-01
Second Mirror                        9    -0.12853D+00   0.14268D-01  -0.10632D-01  -0.56976D-02  -0.51761D-01   0.11068D-01
Sensitive Instrument 2              10    -0.56297D-01   0.51371D-02  -0.24962D-01  -0.35017D-02  -0.32628D-01   0.33839D-02
Sensitive Instrument 2              10    -0.56297D-01   0.51371D-02  -0.24962D-01  -0.35017D-02  -0.32628D-01   0.33839D-02
Sensitive Instrument 3              11    -0.55748D-01   0.73490D-02  -0.40723D-02  -0.32597D-02  -0.32214D-01   0.37598D-02
Sensitive Instrument 4              12    -0.56710D-01   0.77970D-02  -0.10926D-02  -0.32875D-02  -0.32248D-01   0.37276D-02
Sensitive Instrument 5              13    -0.52142D-01   0.70920D-02  -0.31619D-02  -0.32876D-02  -0.32249D-01   0.37277D-02

MODE# 18/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    222.22       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.35707D-02   0.10470D+00   0.27445D-02   0.74395D-02   0.12562D-02  -0.11690D-01
RCS Jet #2    (+X)                  22     0.41034D-02   0.63730D-01   0.23774D-02   0.94111D-02   0.11439D-02  -0.16243D-01
RCS Jet #3    (+Y)                  23    -0.42547D-01  -0.37964D-01  -0.14753D-01   0.82696D-02  -0.83101D-02  -0.15896D-01
RCS Jet #4    (-Y)                  24     0.51293D-01  -0.37859D-01   0.11799D-01   0.84107D-02   0.10018D-01  -0.14962D-01
RCS Jet #5    (-Y)                  25     0.15776D-01   0.54547D-01   0.82284D-02   0.92603D-02   0.53179D-03  -0.16908D-01
RCS Jet #6    (+Y)                  26    -0.73933D-02   0.54469D-01  -0.47531D-02   0.91606D-02   0.18133D-02  -0.16370D-01
RCS Jet #7    (+X)                  27     0.93813D-03   0.12385D+00   0.27868D-02  -0.37296D-01   0.14608D-02  -0.10202D+00
RCS Jet #8    (+X)                  28     0.14250D-02   0.13399D+00   0.27540D-02  -0.37295D-01   0.14612D-02  -0.10203D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.25582D-02   0.55122D-01   0.10842D-02   0.86708D-02   0.13495D-02  -0.31007D-01
Reaction Wheel #2 Spin Axis         18    -0.17015D-01   0.27864D-01  -0.10809D-01   0.13624D-01   0.33509D-03  -0.25969D-01
Reaction Wheel #3 Spin Axis         19     0.17583D-01   0.25617D-01   0.86788D-02   0.12888D-01   0.14153D-02  -0.24820D-01
Cryo Cooler Pump                     8    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01
Cryo Cooler Pump                     8    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01
Cryo Cooler Pump                     8    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.27635D-01  -0.26464D-01   0.87567D-02   0.13730D-01   0.14028D-02  -0.34931D-01
Accelerometers                       7     0.27635D-01  -0.26464D-01   0.87567D-02   0.13730D-01   0.14028D-02  -0.34931D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
