RCS Jet #5    (-Y)                  25     0.15776D-01   0.54547D-01   0.82284D-02   0.92603D-02   0.53179D-03  -0.16908D-01
RCS Jet #6    (+Y)                  26    -0.73933D-02   0.54469D-01  -0.47531D-02   0.91606D-02   0.18133D-02  -0.16370D-01
RCS Jet #7    (+X)                  27     0.93813D-03   0.12385D+00   0.27868D-02  -0.37296D-01   0.14608D-02  -0.10202D+00
RCS Jet #8    (+X)                  28     0.14250D-02   0.13399D+00   0.27540D-02  -0.37295D-01   0.14612D-02  -0.10203D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.25582D-02   0.55122D-01   0.10842D-02   0.86708D-02   0.13495D-02  -0.31007D-01
Reaction Wheel #2 Spin Axis         18    -0.17015D-01   0.27864D-01  -0.10809D-01   0.13624D-01   0.33509D-03  -0.25969D-01
Reaction Wheel #3 Spin Axis         19     0.17583D-01   0.25617D-01   0.86788D-02   0.12888D-01   0.14153D-02  -0.24820D-01
Cryo Cooler Pump                     8    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01
Cryo Cooler Pump                     8    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01
Cryo Cooler Pump                     8    -0.78312D-01  -0.48437D-01  -0.29617D-01   0.31778D-01  -0.17900D-01  -0.29896D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.27635D-01  -0.26464D-01   0.87567D-02   0.13730D-01   0.14028D-02  -0.34931D-01
Accelerometers                       7     0.27635D-01  -0.26464D-01   0.87567D-02   0.13730D-01   0.14028D-02  -0.34931D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors            6     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors            6     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors            6     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors            6     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors            6     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Second Mirror                        9    -0.99949D-01  -0.89154D-01  -0.29045D-01   0.32200D-01  -0.18401D-01  -0.29515D-01
Second Mirror                        9    -0.99949D-01  -0.89154D-01  -0.29045D-01   0.32200D-01  -0.18401D-01  -0.29515D-01
Sensitive Instrument 2              10     0.66256D-01  -0.16165D-01   0.24805D-01   0.14534D-01   0.17873D-02  -0.35474D-01
Sensitive Instrument 2              10     0.66256D-01  -0.16165D-01   0.24805D-01   0.14534D-01   0.17873D-02  -0.35474D-01
Sensitive Instrument 3              11     0.28605D-01  -0.36282D-01   0.92771D-02   0.13726D-01   0.95616D-03  -0.35728D-01
Sensitive Instrument 4              12     0.37712D-01  -0.40509D-01   0.12649D-01   0.13784D-01   0.10552D-02  -0.35710D-01
Sensitive Instrument 5              13     0.37563D-01  -0.36265D-01   0.12716D-01   0.13786D-01   0.10577D-02  -0.35710D-01

MODE# 28/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    225.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.12695D+00  -0.76125D-02  -0.40997D-01  -0.34151D-03  -0.14730D-01   0.26863D-02
RCS Jet #2    (+X)                  22     0.36824D-02  -0.35428D-02  -0.50876D-01  -0.10821D-02  -0.20574D-01   0.21870D-02
RCS Jet #3    (+Y)                  23     0.35599D-02   0.46379D-02   0.26604D-01  -0.20766D-02  -0.26408D-01   0.26394D-02
RCS Jet #4    (-Y)                  24    -0.21576D-02   0.39954D-02   0.25134D-01   0.10711D-02  -0.26557D-01   0.29534D-02
RCS Jet #5    (-Y)                  25     0.98099D-02   0.57123D-03  -0.39892D-01  -0.12221D-02  -0.20408D-01  -0.20198D-01
RCS Jet #6    (+Y)                  26     0.12094D-01  -0.47181D-02  -0.38079D-01  -0.13229D-02  -0.19510D-01   0.21995D-01
RCS Jet #7    (+X)                  27     0.73961D-01  -0.69773D-02  -0.48638D-01   0.75078D-03  -0.19976D-01   0.48721D-02
RCS Jet #8    (+X)                  28     0.67307D-01  -0.71180D-02  -0.48187D-01   0.75072D-03  -0.19967D-01   0.48725D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.74967D-01  -0.15287D-02  -0.23617D-01  -0.15749D-02  -0.23238D-01   0.28752D-03
Reaction Wheel #2 Spin Axis         18     0.75875D-01  -0.11226D-02   0.70946D-02  -0.35550D-02  -0.18632D-01   0.10591D-01
Reaction Wheel #3 Spin Axis         19     0.71359D-01   0.24035D-02   0.78572D-02   0.15332D-02  -0.20057D-01  -0.22264D-02
Cryo Cooler Pump                     8    -0.69803D-01   0.21981D-02  -0.97251D-02  -0.38056D-02  -0.55278D-01   0.12736D-01
Cryo Cooler Pump                     8    -0.69803D-01   0.21981D-02  -0.97251D-02  -0.38056D-02  -0.55278D-01   0.12736D-01
Cryo Cooler Pump                     8    -0.69803D-01   0.21981D-02  -0.97251D-02  -0.38056D-02  -0.55278D-01   0.12736D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.19978D-01   0.27808D-02   0.46684D-02  -0.10784D-02  -0.24349D-01   0.16060D-02
Accelerometers                       7    -0.19978D-01   0.27808D-02   0.46684D-02  -0.10784D-02  -0.24349D-01   0.16060D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors            6    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors            6    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors            6    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors            6    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors            6    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Second Mirror                        9    -0.13682D+00   0.57654D-02  -0.98733D-02  -0.27026D-02  -0.55690D-01   0.13754D-01
Second Mirror                        9    -0.13682D+00   0.57654D-02  -0.98733D-02  -0.27026D-02  -0.55690D-01   0.13754D-01
Sensitive Instrument 2              10    -0.39441D-01   0.30719D-02  -0.11294D-01  -0.15191D-02  -0.24544D-01   0.94702D-03
Sensitive Instrument 2              10    -0.39441D-01   0.30719D-02  -0.11294D-01  -0.15191D-02  -0.24544D-01   0.94702D-03
Sensitive Instrument 3              11    -0.40529D-01   0.37982D-02   0.31325D-02  -0.12684D-02  -0.24108D-01   0.13620D-02
Sensitive Instrument 4              12    -0.40881D-01   0.39627D-02   0.56603D-02  -0.12941D-02  -0.24139D-01   0.13328D-02
Sensitive Instrument 5              13    -0.37461D-01   0.36938D-02   0.41113D-02  -0.12942D-02  -0.24142D-01   0.13330D-02

MODE# 29/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    261.47       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.66483D-01  -0.64591D-01  -0.25806D-01  -0.11771D-01  -0.24568D-02  -0.27084D-01
RCS Jet #2    (+X)                  22     0.52681D-01  -0.10771D+00  -0.36939D-01   0.61284D-01  -0.27631D-01   0.60868D-01
RCS Jet #3    (+Y)                  23     0.67370D-01  -0.83417D-01  -0.34309D-01   0.52474D-02   0.10123D-02  -0.18437D-01
RCS Jet #4    (-Y)                  24     0.13700D-01  -0.78548D-01  -0.46807D-01  -0.16456D-01   0.10301D+00  -0.58080D-02
RCS Jet #5    (-Y)                  25    -0.89782D-01  -0.11219D+00   0.30945D-01   0.73025D-01  -0.30523D-02   0.35484D+00
RCS Jet #6    (+Y)                  26     0.47541D-01  -0.60755D-01  -0.75326D-01   0.76278D-01  -0.65462D-01  -0.69604D-01
RCS Jet #7    (+X)                  27     0.11154D+00  -0.46748D-01   0.89206D-01  -0.65430D-01   0.15602D+00   0.92130D-02
RCS Jet #8    (+X)                  28     0.16355D+00  -0.24728D-01   0.85692D-01  -0.65430D-01   0.15601D+00   0.92075D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.88784D-01  -0.55320D-01  -0.43847D-03   0.21899D-01  -0.96641D-02  -0.31322D-01
Reaction Wheel #2 Spin Axis         18     0.62969D-01  -0.83875D-01  -0.91308D-02   0.23426D-02   0.26150D-02  -0.17278D-02
Reaction Wheel #3 Spin Axis         19     0.35789D-01  -0.80964D-01   0.35163D-02   0.13603D-01   0.23719D-01   0.22984D-01
Cryo Cooler Pump                     8     0.21783D+00  -0.32337D+00  -0.21304D-01   0.22922D+00   0.12024D+00  -0.18770D-02
Cryo Cooler Pump                     8     0.21783D+00  -0.32337D+00  -0.21304D-01   0.22922D+00   0.12024D+00  -0.18770D-02
Cryo Cooler Pump                     8     0.21783D+00  -0.32337D+00  -0.21304D-01   0.22922D+00   0.12024D+00  -0.18770D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.54801D-01  -0.97760D-01   0.67570D-02   0.29466D-01   0.16286D-01   0.14230D-01
Accelerometers                       7     0.54801D-01  -0.97760D-01   0.67570D-02   0.29466D-01   0.16286D-01   0.14230D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors            6     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors            6     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors            6     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors            6     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors            6     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Second Mirror                        9     0.36252D+00  -0.61310D+00  -0.16393D-01   0.22399D+00   0.12032D+00  -0.57643D-02
Second Mirror                        9     0.36252D+00  -0.61310D+00  -0.16393D-01   0.22399D+00   0.12032D+00  -0.57643D-02
Sensitive Instrument 2              10     0.52097D-01  -0.13339D+00   0.50679D-01   0.34297D-01   0.19434D-01   0.16402D-01
Sensitive Instrument 2              10     0.52097D-01  -0.13339D+00   0.50679D-01   0.34297D-01   0.19434D-01   0.16402D-01
Sensitive Instrument 3              11     0.69727D-01  -0.12601D+00   0.88406D-02   0.29056D-01   0.17054D-01   0.15022D-01
Sensitive Instrument 4              12     0.65927D-01  -0.12424D+00   0.14176D-01   0.29246D-01   0.17376D-01   0.15037D-01
Sensitive Instrument 5              13     0.63467D-01  -0.12106D+00   0.15291D-01   0.29250D-01   0.17382D-01   0.15034D-01

MODE# 30/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    282.22       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.66320D-01   0.92400D-01  -0.23428D-01   0.29488D-01  -0.62684D-02   0.23762D-01
RCS Jet #2    (+X)                  22     0.39766D-01   0.67026D-01  -0.34597D-01  -0.50771D-01  -0.33398D-01  -0.32456D-01
RCS Jet #3    (+Y)                  23    -0.27987D-01   0.88738D-02  -0.46427D-01   0.25260D-01   0.11814D+00  -0.18749D-02
RCS Jet #4    (-Y)                  24     0.71349D-01   0.13341D-01  -0.11324D-01  -0.99379D-03  -0.11836D-02  -0.53927D-02
RCS Jet #5    (-Y)                  25     0.33275D-01   0.41559D-01  -0.59737D-01  -0.63236D-01  -0.60556D-01   0.46450D-01
RCS Jet #6    (+Y)                  26    -0.39864D-01   0.71478D-01   0.25911D-01  -0.57356D-01  -0.17052D-01  -0.20107D+00
RCS Jet #7    (+X)                  27     0.12444D+00  -0.32139D-01   0.14066D+00   0.17333D+00   0.21974D+00   0.14966D+00
RCS Jet #8    (+X)                  28     0.19769D+00  -0.86559D-01   0.13571D+00   0.17333D+00   0.21973D+00   0.14969D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.84625D-01   0.38864D-02   0.13614D-01  -0.23304D-01  -0.19769D-01   0.47062D-01
Reaction Wheel #2 Spin Axis         18    -0.81709D-02   0.40103D-01   0.18531D-01   0.97072D-02   0.18163D-01  -0.85334D-01
Reaction Wheel #3 Spin Axis         19     0.61730D-01   0.39304D-01   0.12969D-01   0.14131D-01  -0.82634D-02  -0.88291D-02
Cryo Cooler Pump                     8     0.12296D+00   0.48332D+00   0.63055D-01  -0.42503D+00   0.11951D+00  -0.12614D+00
Cryo Cooler Pump                     8     0.12296D+00   0.48332D+00   0.63055D-01  -0.42503D+00   0.11951D+00  -0.12614D+00
Cryo Cooler Pump                     8     0.12296D+00   0.48332D+00   0.63055D-01  -0.42503D+00   0.11951D+00  -0.12614D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.59052D-01   0.38249D-01  -0.24301D-01  -0.20730D-01   0.10477D-01  -0.25876D-01
Accelerometers                       7     0.59052D-01   0.38249D-01  -0.24301D-01  -0.20730D-01   0.10477D-01  -0.25876D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors            6     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors            6     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors            6     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors            6     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors            6     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Second Mirror                        9     0.27492D+00   0.10318D+01   0.54504D-01  -0.42490D+00   0.12409D+00  -0.12875D+00
Second Mirror                        9     0.27492D+00   0.10318D+01   0.54504D-01  -0.42490D+00   0.12409D+00  -0.12875D+00
Sensitive Instrument 2              10     0.92792D-01   0.72702D-01  -0.41011D-01  -0.20860D-01   0.75746D-02  -0.24462D-01
Sensitive Instrument 2              10     0.92792D-01   0.72702D-01  -0.41011D-01  -0.20860D-01   0.75746D-02  -0.24462D-01
Sensitive Instrument 3              11     0.66568D-01   0.59972D-01  -0.24505D-01  -0.18427D-01   0.73820D-02  -0.25284D-01
Sensitive Instrument 4              12     0.73013D-01   0.56975D-01  -0.30039D-01  -0.18472D-01   0.72971D-02  -0.25226D-01
Sensitive Instrument 5              13     0.71981D-01   0.55976D-01  -0.29571D-01  -0.18473D-01   0.73027D-02  -0.25224D-01

MODE# 31/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    293.17       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.85283D-01   0.48842D-01   0.21237D-01   0.27426D-02   0.95170D-02  -0.45790D-02
RCS Jet #2    (+X)                  22    -0.29984D-01   0.71475D-02   0.22194D-01   0.38206D-02   0.10320D-01  -0.14717D-01
RCS Jet #3    (+Y)                  23    -0.18484D-01   0.17212D-01  -0.23331D-01   0.71263D-02   0.13642D-01   0.10451D-02
RCS Jet #4    (-Y)                  24    -0.39083D-01   0.14478D-01  -0.17709D-02   0.99368D-02  -0.23233D-02  -0.10309D-01
RCS Jet #5    (-Y)                  25    -0.15593D-01   0.28818D-03   0.18265D-01   0.26669D-02   0.82756D-02  -0.26492D-01
RCS Jet #6    (+Y)                  26    -0.39647D-01  -0.12803D-02   0.13885D-01   0.36293D-02   0.11897D-01  -0.13061D-01
RCS Jet #7    (+X)                  27    -0.69738D-01   0.44697D-01  -0.15126D-02  -0.61982D-02  -0.22600D-01  -0.40786D-01
RCS Jet #8    (+X)                  28    -0.77272D-01   0.45847D-01  -0.10039D-02  -0.61972D-02  -0.22600D-01  -0.40789D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.70150D-01   0.30340D-01   0.83129D-02   0.36852D-02   0.10258D-01   0.15013D-02
Reaction Wheel #2 Spin Axis         18    -0.66147D-01   0.33959D-01  -0.13053D-01   0.71456D-02   0.20792D-02  -0.13130D-01
Reaction Wheel #3 Spin Axis         19    -0.59970D-01   0.38350D-01  -0.23195D-03   0.72227D-02  -0.39407D-02   0.14196D-01
Cryo Cooler Pump                     8     0.10493D+00   0.61289D-02   0.98063D-02   0.14124D-01   0.10100D+00  -0.20687D-01
Cryo Cooler Pump                     8     0.10493D+00   0.61289D-02   0.98063D-02   0.14124D-01   0.10100D+00  -0.20687D-01
Cryo Cooler Pump                     8     0.10493D+00   0.61289D-02   0.98063D-02   0.14124D-01   0.10100D+00  -0.20687D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.25379D-01   0.10576D-01  -0.46566D-02   0.51122D-02   0.13373D-01   0.97286D-02
Accelerometers                       7    -0.25379D-01   0.10576D-01  -0.46566D-02   0.51122D-02   0.13373D-01   0.97286D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors            6    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors            6    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors            6    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors            6    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors            6    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Second Mirror                        9     0.22813D+00  -0.76746D-02   0.10286D-01   0.10775D-01   0.10209D+00  -0.23602D-01
Second Mirror                        9     0.22813D+00  -0.76746D-02   0.10286D-01   0.10775D-01   0.10209D+00  -0.23602D-01
Sensitive Instrument 2              10    -0.26752D-01  -0.58290D-03   0.96265D-02   0.63161D-02   0.13642D-01   0.10792D-01
Sensitive Instrument 2              10    -0.26752D-01  -0.58290D-03   0.96265D-02   0.63161D-02   0.13642D-01   0.10792D-01
Sensitive Instrument 3              11    -0.13645D-01   0.45905D-02  -0.44594D-02   0.62879D-02   0.13786D-01   0.10954D-01
Sensitive Instrument 4              12    -0.16438D-01   0.58878D-02  -0.44876D-02   0.62818D-02   0.13781D-01   0.10938D-01
Sensitive Instrument 5              13    -0.18390D-01   0.60759D-02  -0.36033D-02   0.62814D-02   0.13780D-01   0.10938D-01

MODE# 32/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    306.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.51307D-01  -0.31216D-01   0.83142D-01   0.22984D-01   0.19453D-01   0.10293D-01
RCS Jet #2    (+X)                  22     0.56236D-01  -0.19491D+00   0.76059D-01   0.52108D-01   0.25016D-01   0.67080D-01
RCS Jet #3    (+Y)                  23     0.76752D-01  -0.16958D+00   0.11933D-01   0.84684D-02  -0.33563D-01   0.21427D-01
RCS Jet #4    (-Y)                  24     0.56075D-01  -0.16901D+00   0.39545D-01   0.99180D-02   0.47891D-01   0.85697D-02
RCS Jet #5    (-Y)                  25     0.10771D-01  -0.15780D+00   0.10451D+00   0.61345D-01   0.43483D-01   0.64958D-01
RCS Jet #6    (+Y)                  26     0.12807D+00  -0.16750D+00   0.20956D-01   0.56024D-01   0.11153D-01   0.14176D+00
RCS Jet #7    (+X)                  27     0.43470D-02  -0.14826D+00   0.63020D-01   0.30368D-01  -0.44220D-02   0.13210D+00
RCS Jet #8    (+X)                  28     0.28679D-02  -0.15541D+00   0.63124D-01   0.30365D-01  -0.44074D-02   0.13210D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.48814D-02  -0.98564D-01   0.58139D-01   0.48564D-01   0.33910D-01  -0.28856D-02
Reaction Wheel #2 Spin Axis         18     0.51117D-01  -0.11997D+00   0.23766D-01   0.15961D-01   0.80377D-02   0.43298D-01
Reaction Wheel #3 Spin Axis         19     0.38131D-02  -0.11273D+00   0.50453D-01   0.34103D-01   0.24706D-01   0.84524D-03
Cryo Cooler Pump                     8    -0.48224D+00   0.82295D+00  -0.16459D+00  -0.11457D+01  -0.49565D+00   0.44446D-01
Cryo Cooler Pump                     8    -0.48224D+00   0.82295D+00  -0.16459D+00  -0.11457D+01  -0.49565D+00   0.44446D-01
Cryo Cooler Pump                     8    -0.48224D+00   0.82295D+00  -0.16459D+00  -0.11457D+01  -0.49565D+00   0.44446D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.65395D-01  -0.18745D+00   0.38927D-01   0.24577D-01   0.66900D-02  -0.22404D-02
Accelerometers                       7     0.65395D-01  -0.18745D+00   0.38927D-01   0.24577D-01   0.66900D-02  -0.22404D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors            6     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors            6     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors            6     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors            6     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors            6     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Second Mirror                        9    -0.10754D+01   0.22621D+01  -0.19004D+00  -0.11146D+01  -0.49273D+00   0.62998D-01
Second Mirror                        9    -0.10754D+01   0.22621D+01  -0.19004D+00  -0.11146D+01  -0.49273D+00   0.62998D-01
Sensitive Instrument 2              10     0.71919D-01  -0.19256D+00   0.68001D-01   0.29902D-01   0.67172D-02  -0.68000D-02
Sensitive Instrument 2              10     0.71919D-01  -0.19256D+00   0.68001D-01   0.29902D-01   0.67172D-02  -0.68000D-02
Sensitive Instrument 3              11     0.63453D-01  -0.19456D+00   0.40976D-01   0.20563D-01   0.29231D-02  -0.83292D-02
Sensitive Instrument 4              12     0.65611D-01  -0.19555D+00   0.45767D-01   0.20906D-01   0.34644D-02  -0.82675D-02
Sensitive Instrument 5              13     0.65122D-01  -0.19206D+00   0.45989D-01   0.20914D-01   0.34742D-02  -0.82734D-02

MODE# 33/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    314.43       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.99001D-01   0.25032D+00  -0.91390D-01   0.18942D-01  -0.42041D-01  -0.63836D-01
RCS Jet #2    (+X)                  22    -0.14315D+00   0.61516D-01  -0.67851D-01   0.48668D-01  -0.38600D-01  -0.10289D+00
RCS Jet #3    (+Y)                  23    -0.22102D+00  -0.14863D+00   0.48448D-02   0.25597D-01  -0.29995D-01  -0.34606D-01
RCS Jet #4    (-Y)                  24    -0.99920D-01  -0.16354D+00   0.68237D-01   0.24332D-01  -0.26689D-01  -0.12469D+00
RCS Jet #5    (-Y)                  25    -0.98568D-01  -0.94398D-02  -0.98784D-02   0.48446D-01  -0.32783D-01  -0.18206D-01
RCS Jet #6    (+Y)                  26    -0.23543D+00   0.79499D-02  -0.84981D-01   0.57089D-01  -0.52943D-01  -0.15686D+00
RCS Jet #7    (+X)                  27    -0.77724D-01   0.32453D+00  -0.15009D+00  -0.20107D+00  -0.13592D+00  -0.45845D+00
RCS Jet #8    (+X)                  28    -0.12302D+00   0.38125D+00  -0.14704D+00  -0.20106D+00  -0.13595D+00  -0.45850D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.57233D-01   0.70927D-01  -0.37531D-01   0.17063D-01  -0.40897D-01  -0.11212D+00
Reaction Wheel #2 Spin Axis         18    -0.97522D-01  -0.25528D-01  -0.24044D-01   0.35628D-01  -0.54992D-01  -0.90158D-01
Reaction Wheel #3 Spin Axis         19    -0.74935D-02  -0.25587D-01   0.24287D-01   0.38843D-01  -0.28474D-01  -0.79406D-01
Cryo Cooler Pump                     8     0.93351D+00   0.42618D+00   0.20425D+00  -0.41692D+00   0.10308D+01  -0.50328D+00
Cryo Cooler Pump                     8     0.93351D+00   0.42618D+00   0.20425D+00  -0.41692D+00   0.10308D+01  -0.50328D+00
Cryo Cooler Pump                     8     0.93351D+00   0.42618D+00   0.20425D+00  -0.41692D+00   0.10308D+01  -0.50328D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.12006D+00  -0.11679D+00  -0.15440D-02   0.27515D-01   0.19556D-01  -0.27646D-01
Accelerometers                       7    -0.12006D+00  -0.11679D+00  -0.15440D-02   0.27515D-01   0.19556D-01  -0.27646D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors            6    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors            6    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors            6    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors            6    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors            6    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Second Mirror                        9     0.22048D+01   0.10043D+01   0.19780D+00  -0.44737D+00   0.10475D+01  -0.53681D+00
Second Mirror                        9     0.22048D+01   0.10043D+01   0.19780D+00  -0.44737D+00   0.10475D+01  -0.53681D+00
Sensitive Instrument 2              10    -0.84927D-01  -0.13930D+00   0.50290D-01   0.47396D-01   0.21949D-01  -0.18607D-01
Sensitive Instrument 2              10    -0.84927D-01  -0.13930D+00   0.50290D-01   0.47396D-01   0.21949D-01  -0.18607D-01
Sensitive Instrument 3              11    -0.99753D-01  -0.14923D+00  -0.60206D-02   0.40621D-01   0.20458D-01  -0.16622D-01
Sensitive Instrument 4              12    -0.95519D-01  -0.15118D+00   0.18135D-02   0.40789D-01   0.20821D-01  -0.16823D-01
Sensitive Instrument 5              13    -0.98471D-01  -0.14432D+00   0.31494D-02   0.40794D-01   0.20810D-01  -0.16829D-01

MODE# 34/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    316.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.57204D-01   0.39286D-01  -0.11399D-01   0.48988D-02  -0.55992D-02   0.57084D-02
RCS Jet #2    (+X)                  22     0.20150D-01  -0.14483D-01  -0.15543D-01   0.91790D-03  -0.86041D-02   0.44314D-03
RCS Jet #3    (+Y)                  23     0.49967D-01   0.45264D-01  -0.51964D-02   0.13036D-01   0.12324D-01   0.35320D-03
RCS Jet #4    (-Y)                  24    -0.12149D-01   0.47862D-01   0.26166D-01   0.11651D-01  -0.21967D-01   0.13660D-01
RCS Jet #5    (-Y)                  25     0.22863D-01  -0.12608D-01  -0.10823D-01  -0.95167D-04  -0.11720D-01  -0.92216D-02
RCS Jet #6    (+Y)                  26     0.19799D-01  -0.13565D-01  -0.10150D-01  -0.64021D-03  -0.48917D-02  -0.21779D-02
RCS Jet #7    (+X)                  27     0.55254D-01   0.41490D-02   0.16350D-01   0.35214D-01   0.34914D-01   0.29388D-01
RCS Jet #8    (+X)                  28     0.66892D-01  -0.69293D-02   0.15564D-01   0.35214D-01   0.34916D-01   0.29392D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.50962D-01   0.31565D-01  -0.27297D-02   0.34567D-04  -0.87004D-02   0.18734D-01
Reaction Wheel #2 Spin Axis         18     0.46230D-01   0.60866D-01  -0.39489D-03   0.95998D-02   0.90872D-02   0.22906D-01
Reaction Wheel #3 Spin Axis         19     0.39108D-01   0.62033D-01   0.19068D-01   0.94804D-02  -0.13501D-01   0.17663D-01
Cryo Cooler Pump                     8    -0.50371D-01  -0.19692D-01  -0.27177D-01   0.33013D-01  -0.97878D-01   0.66451D-01
Cryo Cooler Pump                     8    -0.50371D-01  -0.19692D-01  -0.27177D-01   0.33013D-01  -0.97878D-01   0.66451D-01
Cryo Cooler Pump                     8    -0.50371D-01  -0.19692D-01  -0.27177D-01   0.33013D-01  -0.97878D-01   0.66451D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.57294D-02   0.28810D-01   0.12717D-01   0.53995D-02  -0.13295D-01   0.23201D-01
Accelerometers                       7    -0.57294D-02   0.28810D-01   0.12717D-01   0.53995D-02  -0.13295D-01   0.23201D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors            6     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors            6     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors            6     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors            6     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors            6     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Second Mirror                        9    -0.17076D+00  -0.64913D-01  -0.26708D-01   0.35467D-01  -0.99055D-01   0.69499D-01
Second Mirror                        9    -0.17076D+00  -0.64913D-01  -0.26708D-01   0.35467D-01  -0.99055D-01   0.69499D-01
Sensitive Instrument 2              10    -0.40182D-01   0.12685D-01   0.97191D-02   0.38360D-02  -0.13747D-01   0.22763D-01
Sensitive Instrument 2              10    -0.40182D-01   0.12685D-01   0.97191D-02   0.38360D-02  -0.13747D-01   0.22763D-01
Sensitive Instrument 3              11    -0.17370D-01   0.24028D-01   0.12042D-01   0.45289D-02  -0.13015D-01   0.22835D-01
Sensitive Instrument 4              12    -0.23192D-01   0.26730D-01   0.14746D-01   0.44954D-02  -0.13072D-01   0.22831D-01
Sensitive Instrument 5              13    -0.21341D-01   0.25902D-01   0.13907D-01   0.44942D-02  -0.13074D-01   0.22831D-01

MODE# 35/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    342.75       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.13244D-02  -0.78431D-02   0.82112D-03   0.39179D-03   0.45778D-03   0.10193D-02
RCS Jet #2    (+X)                  22     0.12787D-02  -0.68198D-02   0.60439D-03  -0.81702D-03   0.64200D-03   0.61079D-03
RCS Jet #3    (+Y)                  23     0.90363D-02   0.56091D-02   0.93256D-03  -0.80473D-03   0.25307D-02  -0.17291D-02
RCS Jet #4    (-Y)                  24    -0.56837D-02   0.58718D-02  -0.19130D-02  -0.66424D-03  -0.25415D-02   0.90848D-06
RCS Jet #5    (-Y)                  25     0.10376D-02  -0.64497D-02  -0.20252D-03  -0.59220D-03   0.10685D-02   0.14418D-03
RCS Jet #6    (+Y)                  26     0.23527D-02  -0.67467D-02   0.75075D-03  -0.77390D-03   0.40110D-03   0.25536D-02
RCS Jet #7    (+X)                  27     0.26678D-03  -0.21341D-01   0.88224D-03   0.16411D-01   0.76325D-03   0.31733D-01
RCS Jet #8    (+X)                  28     0.52119D-03  -0.26098D-01   0.86519D-03   0.16411D-01   0.76372D-03   0.31736D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.16731D-04  -0.64425D-02   0.12681D-03  -0.67801D-03   0.46062D-03   0.40056D-02
Reaction Wheel #2 Spin Axis         18     0.24599D-02  -0.43134D-02   0.17431D-02  -0.26538D-02   0.32239D-03   0.31972D-02
Reaction Wheel #3 Spin Axis         19    -0.16893D-02  -0.43883D-02  -0.22423D-02  -0.25806D-02   0.98782D-03   0.19724D-02
Cryo Cooler Pump                     8    -0.39603D-02  -0.59123D-02   0.63513D-03   0.85996D-02  -0.14207D-01   0.14629D-01
Cryo Cooler Pump                     8    -0.39603D-02  -0.59123D-02   0.63513D-03   0.85996D-02  -0.14207D-01   0.14629D-01
Cryo Cooler Pump                     8    -0.39603D-02  -0.59123D-02   0.63513D-03   0.85996D-02  -0.14207D-01   0.14629D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.26122D-02   0.56432D-02  -0.12065D-02  -0.22222D-02  -0.86539D-03   0.55316D-02
Accelerometers                       7    -0.26122D-02   0.56432D-02  -0.12065D-02  -0.22222D-02  -0.86539D-03   0.55316D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.56751D-03  -0.37713D-03  -0.59432D-03  -0.22326D-02  -0.31380D-03   0.55964D-02
Inertial Attitude Sensors            6     0.56751D-03  -0.37713D-03  -0.59432D-03  -0.22326D-02  -0.31380D-03   0.55964D-02
Inertial Attitude Sensors            6     0.56751D-03  -0.37713D-03  -0.59432D-03  -0.22326D-02  -0.31380D-03   0.55964D-02
Inertial Attitude Sensors            6     0.56751D-03  -0.37713D-03  -0.59432D-03  -0.22326D-02  -0.31380D-03   0.55964D-02
Inertial Attitude Sensors            6     0.56751D-03  -0.37713D-03  -0.59432D-03  -0.22326D-02  -0.31380D-03   0.55964D-02
Inertial Attitude Sensors            6     0.56751D-03  -0.37713D-03  -0.59432D-03  -0.22326D-02  -0.31380D-03   0.55964D-02
Second Mirror                        9    -0.21611D-01  -0.17510D-01   0.79546D-03   0.89638D-02  -0.14431D-01   0.15142D-01
Second Mirror                        9    -0.21611D-01  -0.17510D-01   0.79546D-03   0.89638D-02  -0.14431D-01   0.15142D-01
Sensitive Instrument 2              10    -0.91617D-02   0.44005D-02  -0.45415D-02  -0.29076D-02  -0.10038D-02   0.55255D-02
Sensitive Instrument 2              10    -0.91617D-02   0.44005D-02  -0.45415D-02  -0.29076D-02  -0.10038D-02   0.55255D-02
Sensitive Instrument 3              11    -0.33152D-02   0.74441D-02  -0.13034D-02  -0.25004D-02  -0.67448D-03   0.55944D-02
Sensitive Instrument 4              12    -0.47426D-02   0.81064D-02  -0.18551D-02  -0.25250D-02  -0.71654D-03   0.55900D-02
Sensitive Instrument 5              13    -0.46413D-02   0.73899D-02  -0.19011D-02  -0.25254D-02  -0.71734D-03   0.55903D-02

MODE# 36/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    343.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.19271D-02  -0.19494D-02   0.36329D-02   0.65452D-04  -0.19118D-04   0.33936D-03
RCS Jet #2    (+X)                  22     0.94254D-03  -0.16249D-02   0.52960D-02  -0.23152D-04   0.36850D-03   0.69521D-03
RCS Jet #3    (+Y)                  23     0.14436D-02  -0.71514D-03   0.43751D-02  -0.23690D-03   0.24396D-04  -0.10361D-03
RCS Jet #4    (-Y)                  24     0.87083D-03  -0.53455D-03   0.37194D-02  -0.23071D-03   0.44594D-03   0.77178D-03
RCS Jet #5    (-Y)                  25    -0.43878D-03  -0.15633D-02   0.50762D-02  -0.14062D-04   0.35646D-03   0.33008D-02
RCS Jet #6    (+Y)                  26     0.63666D-03  -0.94294D-03   0.50607D-02   0.27973D-04   0.17838D-03  -0.16057D-02
RCS Jet #7    (+X)                  27    -0.11327D-02  -0.40321D-02   0.48607D-02   0.24604D-02   0.23710D-03   0.54523D-02
RCS Jet #8    (+X)                  28    -0.10547D-02  -0.47297D-02   0.48548D-02   0.24602D-02   0.23496D-03   0.54530D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.20091D-02  -0.17333D-02   0.58762D-02   0.46912D-03   0.23323D-02   0.96133D-03
Reaction Wheel #2 Spin Axis         18     0.40860D-03  -0.22536D-02   0.53787D-02  -0.15947D-02  -0.21125D-03   0.11071D-02
Reaction Wheel #3 Spin Axis         19    -0.51569D-03  -0.96136D-03   0.47879D-02   0.85528D-03  -0.20963D-03   0.19642D-03
Cryo Cooler Pump                     8    -0.48378D-02   0.28757D-02   0.47514D-02  -0.38086D-02  -0.58438D-02   0.25092D-02
Cryo Cooler Pump                     8    -0.48378D-02   0.28757D-02   0.47514D-02  -0.38086D-02  -0.58438D-02   0.25092D-02
Cryo Cooler Pump                     8    -0.48378D-02   0.28757D-02   0.47514D-02  -0.38086D-02  -0.58438D-02   0.25092D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.13992D-02  -0.59257D-03   0.51080D-02  -0.34122D-03   0.45504D-03   0.12179D-03
Accelerometers                       7     0.13992D-02  -0.59257D-03   0.51080D-02  -0.34122D-03   0.45504D-03   0.12179D-03

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.13624D-02  -0.68683D-03   0.56039D-02  -0.38102D-03   0.19276D-03   0.10081D-03
Inertial Attitude Sensors            6     0.13624D-02  -0.68683D-03   0.56039D-02  -0.38102D-03   0.19276D-03   0.10081D-03
Inertial Attitude Sensors            6     0.13624D-02  -0.68683D-03   0.56039D-02  -0.38102D-03   0.19276D-03   0.10081D-03
Inertial Attitude Sensors            6     0.13624D-02  -0.68683D-03   0.56039D-02  -0.38102D-03   0.19276D-03   0.10081D-03
Inertial Attitude Sensors            6     0.13624D-02  -0.68683D-03   0.56039D-02  -0.38102D-03   0.19276D-03   0.10081D-03
Inertial Attitude Sensors            6     0.13624D-02  -0.68683D-03   0.56039D-02  -0.38102D-03   0.19276D-03   0.10081D-03
Second Mirror                        9    -0.11993D-01   0.76208D-02   0.46677D-02  -0.34759D-02  -0.58963D-02   0.27493D-02
Second Mirror                        9    -0.11993D-01   0.76208D-02   0.46677D-02  -0.34759D-02  -0.58963D-02   0.27493D-02
Sensitive Instrument 2              10     0.15742D-02  -0.29296D-03   0.50341D-02  -0.49384D-03   0.35742D-03   0.98382D-04
Sensitive Instrument 2              10     0.15742D-02  -0.29296D-03   0.50341D-02  -0.49384D-03   0.35742D-03   0.98382D-04
Sensitive Instrument 3              11     0.16847D-02  -0.19259D-03   0.52273D-02  -0.45635D-03   0.36198D-03   0.62395D-04
Sensitive Instrument 4              12     0.16683D-02  -0.18627D-03   0.50681D-02  -0.44968D-03   0.36250D-03   0.80546D-04
Sensitive Instrument 5              13     0.16171D-02  -0.25517D-03   0.50913D-02  -0.44966D-03   0.36296D-03   0.80587D-04

MODE# 37/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    367.90       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.69874D-01   0.31503D-01  -0.88844D-02   0.59836D-03  -0.56896D-02  -0.80714D-02
RCS Jet #2    (+X)                  22    -0.15367D-01   0.42147D-02  -0.26953D-01   0.43685D-02  -0.19169D-01  -0.10289D-01
RCS Jet #3    (+Y)                  23    -0.17458D-01   0.18124D-02   0.25413D-01  -0.16604D-02  -0.35288D-01  -0.39264D-02
RCS Jet #4    (-Y)                  24    -0.23157D-01  -0.10294D-02   0.38443D-01   0.12329D-01  -0.42631D-01  -0.56838D-02
RCS Jet #5    (-Y)                  25    -0.41535D-02  -0.11417D-03  -0.13282D-01   0.33521D-02  -0.19835D-01  -0.21943D-01
RCS Jet #6    (+Y)                  26    -0.18976D-01  -0.31716D-02  -0.19411D-01   0.53441D-02  -0.19460D-01   0.59240D-03
RCS Jet #7    (+X)                  27     0.44478D-01   0.44873D-01  -0.11122D-01  -0.27826D-01  -0.17755D-04  -0.66376D-01
RCS Jet #8    (+X)                  28     0.44477D-01   0.52658D-01  -0.11119D-01  -0.27824D-01  -0.52535D-05  -0.66383D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.44331D-01   0.18053D-01  -0.89743D-02  -0.24794D-02  -0.21467D-01  -0.11395D-01
Reaction Wheel #2 Spin Axis         18     0.39064D-01   0.85047D-02   0.20417D-01  -0.10437D-01  -0.16372D-01   0.79849D-02
Reaction Wheel #3 Spin Axis         19     0.44657D-01   0.25772D-01   0.31691D-01   0.20197D-01  -0.24791D-01  -0.43308D-02
Cryo Cooler Pump                     8     0.40456D-01   0.18324D-01   0.21913D-01  -0.71863D-02   0.58501D-01  -0.28816D-01
Cryo Cooler Pump                     8     0.40456D-01   0.18324D-01   0.21913D-01  -0.71863D-02   0.58501D-01  -0.28816D-01
Cryo Cooler Pump                     8     0.40456D-01   0.18324D-01   0.21913D-01  -0.71863D-02   0.58501D-01  -0.28816D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.35610D-01  -0.83032D-03   0.17648D-01   0.31855D-02  -0.15523D-01   0.35942D-02
Accelerometers                       7    -0.35610D-01  -0.83032D-03   0.17648D-01   0.31855D-02  -0.15523D-01   0.35942D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.33564D-01  -0.49925D-02   0.29958D-04   0.34866D-02  -0.15226D-01   0.37544D-02
Inertial Attitude Sensors            6    -0.33564D-01  -0.49925D-02   0.29958D-04   0.34866D-02  -0.15226D-01   0.37544D-02
Inertial Attitude Sensors            6    -0.33564D-01  -0.49925D-02   0.29958D-04   0.34866D-02  -0.15226D-01   0.37544D-02
Inertial Attitude Sensors            6    -0.33564D-01  -0.49925D-02   0.29958D-04   0.34866D-02  -0.15226D-01   0.37544D-02
Inertial Attitude Sensors            6    -0.33564D-01  -0.49925D-02   0.29958D-04   0.34866D-02  -0.15226D-01   0.37544D-02
Inertial Attitude Sensors            6    -0.33564D-01  -0.49925D-02   0.29958D-04   0.34866D-02  -0.15226D-01   0.37544D-02
Second Mirror                        9     0.11282D+00   0.31821D-01   0.21954D-01  -0.96364D-02   0.59495D-01  -0.31301D-01
Second Mirror                        9     0.11282D+00   0.31821D-01   0.21954D-01  -0.96364D-02   0.59495D-01  -0.31301D-01
Sensitive Instrument 2              10    -0.52610D-01  -0.71219D-02   0.12430D-01   0.41844D-02  -0.15661D-01   0.34319D-02
Sensitive Instrument 2              10    -0.52610D-01  -0.71219D-02   0.12430D-01   0.41844D-02  -0.15661D-01   0.34319D-02
Sensitive Instrument 3              11    -0.48826D-01  -0.50270D-02   0.15597D-01   0.43126D-02  -0.14570D-01   0.47653D-02
Sensitive Instrument 4              12    -0.50056D-01  -0.44545D-02   0.18409D-01   0.42796D-02  -0.14616D-01   0.47138D-02
Sensitive Instrument 5              13    -0.47986D-01  -0.41506D-02   0.17471D-01   0.42797D-02  -0.14623D-01   0.47136D-02

MODE# 38/ 38, Frequency (rad/sec), Damping (zeta), Generalized Mass=    370.02       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.65675D-04   0.64812D-01   0.17540D-02   0.23636D-02   0.14939D-03  -0.13139D-01
RCS Jet #2    (+X)                  22     0.12176D-02  -0.65682D-02   0.14949D-02   0.10105D-01   0.59831D-03  -0.18132D-01
RCS Jet #3    (+Y)                  23     0.28899D-01   0.20367D-01  -0.15188D-01   0.14568D-01   0.17370D-01  -0.10114D-01
RCS Jet #4    (-Y)                  24    -0.25148D-01   0.21175D-01   0.17992D-01   0.13778D-01  -0.15115D-01  -0.66631D-02
RCS Jet #5    (-Y)                  25     0.15199D-01  -0.16587D-01   0.84267D-02   0.10477D-01   0.50382D-03  -0.21422D-01
RCS Jet #6    (+Y)                  26    -0.10267D-01  -0.17470D-01  -0.59023D-02   0.99582D-02   0.12376D-02  -0.14218D-01
RCS Jet #7    (+X)                  27     0.31084D-02   0.69220D-01   0.68774D-02  -0.31484D-01   0.75460D-02  -0.92759D-01
RCS Jet #8    (+X)                  28     0.56231D-02   0.77631D-01   0.67077D-02  -0.31482D-01   0.75466D-02  -0.92771D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.12784D-02   0.38194D-01   0.27085D-02   0.24972D-03   0.41105D-03  -0.52138D-02
Reaction Wheel #2 Spin Axis         18    -0.35648D-02   0.48746D-01  -0.94602D-02   0.12552D-01   0.60326D-02   0.31633D-02
Reaction Wheel #3 Spin Axis         19     0.31942D-02   0.50771D-01   0.15136D-01   0.10865D-01  -0.11050D-01   0.13406D-01
Cryo Cooler Pump                     8     0.14873D-01   0.44005D-02  -0.23020D-01  -0.78295D-02  -0.24498D-01   0.36740D-01
Cryo Cooler Pump                     8     0.14873D-01   0.44005D-02  -0.23020D-01  -0.78295D-02  -0.24498D-01   0.36740D-01
Cryo Cooler Pump                     8     0.14873D-01   0.44005D-02  -0.23020D-01  -0.78295D-02  -0.24498D-01   0.36740D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.13783D-01   0.98397D-02   0.80917D-02   0.94667D-02  -0.24112D-02   0.21419D-01
Accelerometers                       7    -0.13783D-01   0.98397D-02   0.80917D-02   0.94667D-02  -0.24112D-02   0.21419D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.19067D-02  -0.14218D-01   0.11553D-02   0.10949D-01  -0.12077D-02   0.21556D-01
Inertial Attitude Sensors            6    -0.19067D-02  -0.14218D-01   0.11553D-02   0.10949D-01  -0.12077D-02   0.21556D-01
Inertial Attitude Sensors            6    -0.19067D-02  -0.14218D-01   0.11553D-02   0.10949D-01  -0.12077D-02   0.21556D-01
Inertial Attitude Sensors            6    -0.19067D-02  -0.14218D-01   0.11553D-02   0.10949D-01  -0.12077D-02   0.21556D-01
Inertial Attitude Sensors            6    -0.19067D-02  -0.14218D-01   0.11553D-02   0.10949D-01  -0.12077D-02   0.21556D-01
Inertial Attitude Sensors            6    -0.19067D-02  -0.14218D-01   0.11553D-02   0.10949D-01  -0.12077D-02   0.21556D-01
Second Mirror                        9    -0.15138D-01   0.13496D-01  -0.23303D-01  -0.70682D-02  -0.24440D-01   0.37733D-01
Second Mirror                        9    -0.15138D-01   0.13496D-01  -0.23303D-01  -0.70682D-02  -0.24440D-01   0.37733D-01
Sensitive Instrument 2              10    -0.39165D-01  -0.10016D-01   0.17134D-01   0.10144D-01  -0.21768D-02   0.21822D-01
Sensitive Instrument 2              10    -0.39165D-01  -0.10016D-01   0.17134D-01   0.10144D-01  -0.21768D-02   0.21822D-01
Sensitive Instrument 3              11    -0.16106D-01   0.95660D-03   0.77443D-02   0.94364D-02  -0.18616D-02   0.21870D-01
Sensitive Instrument 4              12    -0.21680D-01   0.35456D-02   0.10364D-01   0.94427D-02  -0.18437D-02   0.21847D-01
Sensitive Instrument 5              13    -0.21419D-01   0.34817D-02   0.10246D-01   0.94422D-02  -0.18467D-02   0.21846D-01

MODE# 39/ 39, Frequency (rad/sec), Damping (zeta), Generalized Mass=    370.57       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.33962D-01   0.53541D-02  -0.79767D-02   0.28214D-03  -0.19830D-02  -0.54252D-03
RCS Jet #2    (+X)                  22    -0.48967D-02   0.34698D-02  -0.17982D-01   0.51318D-03  -0.99776D-02  -0.22510D-02
RCS Jet #3    (+Y)                  23    -0.10472D-01  -0.19544D-02   0.11501D-01  -0.18986D-02  -0.16732D-01  -0.13254D-02
RCS Jet #4    (-Y)                  24    -0.53173D-02  -0.26289D-02   0.13037D-01   0.29804D-02  -0.16648D-01  -0.61493D-03
RCS Jet #5    (-Y)                  25    -0.95858D-03   0.31015D-02  -0.12070D-01   0.50341D-04  -0.10144D-01  -0.91752D-02
RCS Jet #6    (+Y)                  26    -0.42538D-02   0.13015D-02  -0.12765D-01   0.92215D-03  -0.10059D-01   0.43357D-02
RCS Jet #7    (+X)                  27     0.26474D-01   0.12183D-01  -0.89021D-02  -0.99448D-02   0.11977D-02  -0.20105D-01
RCS Jet #8    (+X)                  28     0.26876D-01   0.15046D-01  -0.89275D-02  -0.99443D-02   0.12044D-02  -0.20107D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.28076D-01   0.33738D-02  -0.95317D-02  -0.19687D-02  -0.11835D-01  -0.56084D-02
Reaction Wheel #2 Spin Axis         18     0.24198D-01  -0.10842D-02   0.70059D-02  -0.42022D-02  -0.67330D-02   0.56874D-02
Reaction Wheel #3 Spin Axis         19     0.25903D-01   0.34401D-02   0.88845D-02   0.57176D-02  -0.83783D-02  -0.65298D-02
Cryo Cooler Pump                     8     0.17858D-01   0.60491D-02   0.99070D-02  -0.31957D-03   0.30004D-01  -0.19123D-01
Cryo Cooler Pump                     8     0.17858D-01   0.60491D-02   0.99070D-02  -0.31957D-03   0.30004D-01  -0.19123D-01
Cryo Cooler Pump                     8     0.17858D-01   0.60491D-02   0.99070D-02  -0.31957D-03   0.30004D-01  -0.19123D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.13268D-01  -0.14216D-02   0.41345D-02   0.27142D-03  -0.81581D-02  -0.13883D-02
Accelerometers                       7    -0.13268D-01  -0.14216D-02   0.41345D-02   0.27142D-03  -0.81581D-02  -0.13883D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.13947D-01   0.39386D-04  -0.44701D-02   0.27828D-03  -0.80102D-02  -0.13363D-02
Inertial Attitude Sensors            6    -0.13947D-01   0.39386D-04  -0.44701D-02   0.27828D-03  -0.80102D-02  -0.13363D-02
Inertial Attitude Sensors            6    -0.13947D-01   0.39386D-04  -0.44701D-02   0.27828D-03  -0.80102D-02  -0.13363D-02
Inertial Attitude Sensors            6    -0.13947D-01   0.39386D-04  -0.44701D-02   0.27828D-03  -0.80102D-02  -0.13363D-02
Inertial Attitude Sensors            6    -0.13947D-01   0.39386D-04  -0.44701D-02   0.27828D-03  -0.80102D-02  -0.13363D-02
Inertial Attitude Sensors            6    -0.13947D-01   0.39386D-04  -0.44701D-02   0.27828D-03  -0.80102D-02  -0.13363D-02
Second Mirror                        9     0.54983D-01   0.84901D-02   0.10000D-01  -0.16536D-02   0.30462D-01  -0.20447D-01
Second Mirror                        9     0.54983D-01   0.84901D-02   0.10000D-01  -0.16536D-02   0.30462D-01  -0.20447D-01
Sensitive Instrument 2              10    -0.18426D-01  -0.16080D-02  -0.25822D-03   0.69996D-03  -0.82170D-02  -0.15163D-02
Sensitive Instrument 2              10    -0.18426D-01  -0.16080D-02  -0.25822D-03   0.69996D-03  -0.82170D-02  -0.15163D-02
Sensitive Instrument 3              11    -0.20113D-01  -0.22327D-02   0.31306D-02   0.82025D-03  -0.77735D-02  -0.91538D-03
Sensitive Instrument 4              12    -0.19886D-01  -0.23365D-02   0.42555D-02   0.80006D-03  -0.77964D-02  -0.94795D-03
Sensitive Instrument 5              13    -0.18782D-01  -0.21623D-02   0.37552D-02   0.80017D-03  -0.77993D-02  -0.94804D-03

MODE# 40/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    383.62       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.64370D-01  -0.54530D-01   0.16539D-01  -0.21739D-02   0.83738D-02   0.79646D-02
RCS Jet #2    (+X)                  22     0.11352D-01  -0.57500D-02   0.19713D-01  -0.76775D-02   0.94376D-02   0.14578D-01
RCS Jet #3    (+Y)                  23     0.27684D-02  -0.52338D-02  -0.17939D-01  -0.24239D-02   0.43051D-01   0.21506D-01
RCS Jet #4    (-Y)                  24     0.19824D-01  -0.10655D-01  -0.44696D-01  -0.19598D-01   0.63601D-01  -0.12894D-01
RCS Jet #5    (-Y)                  25    -0.60284D-03   0.19787D-02   0.88058D-02  -0.79031D-02   0.95483D-02   0.19410D-01
RCS Jet #6    (+Y)                  26     0.20532D-01   0.29995D-02   0.19460D-01  -0.72554D-02   0.84080D-02   0.11353D-01
RCS Jet #7    (+X)                  27    -0.30863D-01  -0.90707D-01   0.12511D-01   0.66738D-01  -0.58925D-03   0.14544D+00
RCS Jet #8    (+X)                  28    -0.31062D-01  -0.10969D+00   0.12524D-01   0.66734D-01  -0.59232D-03   0.14546D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.32935D-01  -0.35620D-01   0.67394D-02   0.25655D-02   0.14381D-01   0.14768D-01
Reaction Wheel #2 Spin Axis         18    -0.26613D-01  -0.44617D-01  -0.41809D-02  -0.10212D-01  -0.51524D-03  -0.24644D-01
Reaction Wheel #3 Spin Axis         19    -0.35917D-01  -0.33693D-01  -0.27458D-01  -0.12821D-01   0.14687D-01   0.17282D-01
Cryo Cooler Pump                     8    -0.33820D-01  -0.16472D-01  -0.44662D-02   0.93934D-02  -0.35208D-01   0.15806D-01
Cryo Cooler Pump                     8    -0.33820D-01  -0.16472D-01  -0.44662D-02   0.93934D-02  -0.35208D-01   0.15806D-01
Cryo Cooler Pump                     8    -0.33820D-01  -0.16472D-01  -0.44662D-02   0.93934D-02  -0.35208D-01   0.15806D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.29625D-01  -0.13250D-02  -0.20405D-01  -0.78658D-02   0.16961D-01  -0.77110D-02
Accelerometers                       7     0.29625D-01  -0.13250D-02  -0.20405D-01  -0.78658D-02   0.16961D-01  -0.77110D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.25151D-01   0.79853D-02   0.10485D-02  -0.91974D-02   0.15859D-01  -0.80891D-02
Inertial Attitude Sensors            6     0.25151D-01   0.79853D-02   0.10485D-02  -0.91974D-02   0.15859D-01  -0.80891D-02
Inertial Attitude Sensors            6     0.25151D-01   0.79853D-02   0.10485D-02  -0.91974D-02   0.15859D-01  -0.80891D-02
Inertial Attitude Sensors            6     0.25151D-01   0.79853D-02   0.10485D-02  -0.91974D-02   0.15859D-01  -0.80891D-02
Inertial Attitude Sensors            6     0.25151D-01   0.79853D-02   0.10485D-02  -0.91974D-02   0.15859D-01  -0.80891D-02
Inertial Attitude Sensors            6     0.25151D-01   0.79853D-02   0.10485D-02  -0.91974D-02   0.15859D-01  -0.80891D-02
Second Mirror                        9    -0.77788D-01  -0.31793D-01  -0.43653D-02   0.11141D-01  -0.36074D-01   0.17508D-01
Second Mirror                        9    -0.77788D-01  -0.31793D-01  -0.43653D-02   0.11141D-01  -0.36074D-01   0.17508D-01
Sensitive Instrument 2              10     0.51722D-01   0.10493D-01  -0.19321D-01  -0.88730D-02   0.16780D-01  -0.75923D-02
Sensitive Instrument 2              10     0.51722D-01   0.10493D-01  -0.19321D-01  -0.88730D-02   0.16780D-01  -0.75923D-02
Sensitive Instrument 3              11     0.43874D-01   0.65029D-02  -0.18452D-01  -0.85036D-02   0.15882D-01  -0.87245D-02
Sensitive Instrument 4              12     0.46110D-01   0.54628D-02  -0.22484D-01  -0.84935D-02   0.15888D-01  -0.86756D-02
Sensitive Instrument 5              13     0.43860D-01   0.48160D-02  -0.21464D-01  -0.84935D-02   0.15894D-01  -0.86749D-02

MODE# 41/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    391.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.29669D-01   0.83330D-01   0.24088D-01  -0.55618D-03   0.32708D-02  -0.13319D-01
RCS Jet #2    (+X)                  22     0.99794D-01   0.10425D-01   0.25955D-01   0.11671D-01  -0.13105D-01  -0.28247D-01
RCS Jet #3    (+Y)                  23     0.11454D+00   0.46129D-01  -0.10567D+00   0.76354D-01   0.32437D+00   0.11078D+00
RCS Jet #4    (-Y)                  24     0.52196D-01  -0.36874D-03  -0.66374D-01  -0.45067D-01   0.30858D+00  -0.16216D+00
RCS Jet #5    (-Y)                  25     0.11369D+00  -0.76319D-02   0.40099D-01   0.85949D-02  -0.18311D-01  -0.11264D-01
RCS Jet #6    (+Y)                  26     0.75358D-01  -0.41898D-02   0.24262D-01   0.14519D-01  -0.13780D-01  -0.41081D-01
RCS Jet #7    (+X)                  27     0.82831D-01   0.15615D+00   0.11267D+00  -0.11458D+00   0.11152D+00  -0.25350D+00
RCS Jet #8    (+X)                  28     0.11999D+00   0.18865D+00   0.11015D+00  -0.11457D+00   0.11150D+00  -0.25354D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.85807D-01   0.62956D-01   0.19585D-02  -0.10069D-01   0.93949D-03  -0.27439D-01
Reaction Wheel #2 Spin Axis         18     0.27437D-01   0.17575D-01  -0.34945D-01  -0.48398D-02   0.32904D-01  -0.88865D-01
Reaction Wheel #3 Spin Axis         19     0.51600D-01   0.14199D+00   0.34030D-02   0.38392D-01  -0.25028D-02   0.11537D+00
Cryo Cooler Pump                     8    -0.51832D-01  -0.32156D-01  -0.85465D-01  -0.78078D-02  -0.18868D+00   0.13102D+00
Cryo Cooler Pump                     8    -0.51832D-01  -0.32156D-01  -0.85465D-01  -0.78078D-02  -0.18868D+00   0.13102D+00
Cryo Cooler Pump                     8    -0.51832D-01  -0.32156D-01  -0.85465D-01  -0.78078D-02  -0.18868D+00   0.13102D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.10691D+00   0.11874D-01  -0.10896D-01   0.22037D-01   0.46754D-01   0.23971D-01
Accelerometers                       7     0.10691D+00   0.11874D-01  -0.10896D-01   0.22037D-01   0.46754D-01   0.23971D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors            6     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors            6     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors            6     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors            6     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors            6     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Second Mirror                        9    -0.28455D+00  -0.35336D-01  -0.86352D-01   0.43012D-03  -0.19092D+00   0.13951D+00
Second Mirror                        9    -0.28455D+00  -0.35336D-01  -0.86352D-01   0.43012D-03  -0.19092D+00   0.13951D+00
Sensitive Instrument 2              10     0.11759D+00  -0.16158D-01   0.44189D-01   0.26063D-01   0.46619D-01   0.26255D-01
Sensitive Instrument 2              10     0.11759D+00  -0.16158D-01   0.44189D-01   0.26063D-01   0.46619D-01   0.26255D-01
Sensitive Instrument 3              11     0.14299D+00  -0.55181D-02  -0.36675D-02   0.21626D-01   0.41622D-01   0.20545D-01
Sensitive Instrument 4              12     0.13782D+00  -0.31247D-02  -0.30841D-02   0.21940D-01   0.42090D-01   0.20790D-01
Sensitive Instrument 5              13     0.13187D+00  -0.13497D-02  -0.38304D-03   0.21940D-01   0.42115D-01   0.20788D-01

MODE# 42/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    394.70       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.42960D-01   0.40362D-01   0.23143D-02   0.67345D-02  -0.75683D-03  -0.73393D-02
RCS Jet #2    (+X)                  22     0.15169D-01   0.14822D-01  -0.78119D-02   0.26002D-02  -0.12502D-01   0.18064D-01
RCS Jet #3    (+Y)                  23    -0.16894D-01   0.16847D-02  -0.10716D-01   0.11711D-01   0.35788D-01   0.51690D-01
RCS Jet #4    (-Y)                  24     0.33956D-01  -0.10080D-01   0.56764D-02  -0.41354D-02   0.50803D-01  -0.84562D-02
RCS Jet #5    (-Y)                  25     0.47149D-02   0.26487D-01   0.88648D-05   0.34746D-03  -0.15324D-01   0.10529D-01
RCS Jet #6    (+Y)                  26     0.27290D-01   0.25628D-01  -0.23549D-02   0.28996D-02  -0.11640D-01   0.15808D-01
RCS Jet #7    (+X)                  27     0.42707D-01   0.84004D-01   0.20253D-01  -0.89672D-01   0.25986D-01  -0.14786D+00
RCS Jet #8    (+X)                  28     0.51368D-01   0.11057D+00   0.19668D-01  -0.89669D-01   0.25987D-01  -0.14789D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.43703D-01   0.31060D-01  -0.59369D-02  -0.85972D-03  -0.12569D-01  -0.10772D-01
Reaction Wheel #2 Spin Axis         18     0.33215D-01   0.19984D-01   0.17529D-02  -0.99262D-02  -0.30032D-02  -0.37914D-02
Reaction Wheel #3 Spin Axis         19     0.31125D-01   0.59555D-01   0.20453D-01   0.20850D-01  -0.13355D-01   0.32099D-01
Cryo Cooler Pump                     8    -0.18700D-01   0.26435D-02  -0.15771D-01  -0.14358D-01   0.89604D-02  -0.39048D-01
Cryo Cooler Pump                     8    -0.18700D-01   0.26435D-02  -0.15771D-01  -0.14358D-01   0.89604D-02  -0.39048D-01
Cryo Cooler Pump                     8    -0.18700D-01   0.26435D-02  -0.15771D-01  -0.14358D-01   0.89604D-02  -0.39048D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.25537D-01  -0.16938D-01   0.86238D-02   0.12229D-01   0.56416D-02  -0.20358D-01
Accelerometers                       7     0.25537D-01  -0.16938D-01   0.86238D-02   0.12229D-01   0.56416D-02  -0.20358D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.13207D-01   0.50465D-02   0.50781D-02   0.12970D-01   0.17788D-02  -0.20962D-01
Inertial Attitude Sensors            6     0.13207D-01   0.50465D-02   0.50781D-02   0.12970D-01   0.17788D-02  -0.20962D-01
Inertial Attitude Sensors            6     0.13207D-01   0.50465D-02   0.50781D-02   0.12970D-01   0.17788D-02  -0.20962D-01
Inertial Attitude Sensors            6     0.13207D-01   0.50465D-02   0.50781D-02   0.12970D-01   0.17788D-02  -0.20962D-01
Inertial Attitude Sensors            6     0.13207D-01   0.50465D-02   0.50781D-02   0.12970D-01   0.17788D-02  -0.20962D-01
Inertial Attitude Sensors            6     0.13207D-01   0.50465D-02   0.50781D-02   0.12970D-01   0.17788D-02  -0.20962D-01
Second Mirror                        9    -0.71143D-02   0.20958D-01  -0.16130D-01  -0.14330D-01   0.90664D-02  -0.39515D-01
Second Mirror                        9    -0.71143D-02   0.20958D-01  -0.16130D-01  -0.14330D-01   0.90664D-02  -0.39515D-01
Sensitive Instrument 2              10     0.51938D-01  -0.15200D-01   0.27842D-01   0.15780D-01   0.61490D-02  -0.20646D-01
Sensitive Instrument 2              10     0.51938D-01  -0.15200D-01   0.27842D-01   0.15780D-01   0.61490D-02  -0.20646D-01
Sensitive Instrument 3              11     0.29294D-01  -0.26952D-01   0.10034D-01   0.13351D-01   0.38472D-02  -0.21695D-01
Sensitive Instrument 4              12     0.34840D-01  -0.29526D-01   0.12952D-01   0.13524D-01   0.41282D-02  -0.21626D-01
Sensitive Instrument 5              13     0.34257D-01  -0.26222D-01   0.13217D-01   0.13525D-01   0.41357D-02  -0.21629D-01

MODE# 43/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    398.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.28734D-01  -0.69570D+00  -0.22469D-01  -0.52416D-02   0.29524D-02   0.11213D+00
RCS Jet #2    (+X)                  22     0.23344D-01  -0.11104D+00  -0.33529D-01  -0.96374D-01  -0.15079D-01   0.22109D+00
RCS Jet #3    (+Y)                  23    -0.14418D+00  -0.14662D+00   0.14075D+00  -0.13994D+00  -0.10176D+00   0.12625D+00
RCS Jet #4    (-Y)                  24     0.16949D+00  -0.16038D+00  -0.20481D+00  -0.14934D+00   0.16590D+00   0.60776D-01
RCS Jet #5    (-Y)                  25    -0.14452D+00   0.11088D-01  -0.92396D-01  -0.98246D-01  -0.60788D-02   0.25543D+00
RCS Jet #6    (+Y)                  26     0.17182D+00   0.17656D-01   0.39889D-01  -0.91688D-01  -0.30119D-01   0.20000D+00
RCS Jet #7    (+X)                  27     0.24440D-01  -0.14619D+01  -0.53854D-01   0.12431D+01  -0.39672D-01   0.25424D+01
RCS Jet #8    (+X)                  28     0.11224D-01  -0.18191D+01  -0.52962D-01   0.12430D+01  -0.39672D-01   0.25427D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.44675D-01  -0.50513D+00  -0.46203D-01   0.31952D-01  -0.16807D-01   0.18066D+00
Reaction Wheel #2 Spin Axis         18     0.13698D+00  -0.58133D+00   0.12428D+00  -0.17110D+00  -0.55991D-01   0.35195D-01
Reaction Wheel #3 Spin Axis         19    -0.33903D-01  -0.59074D+00  -0.20532D+00  -0.13954D+00   0.15356D+00  -0.11540D+00
Cryo Cooler Pump                     8    -0.15981D+00  -0.45291D-01   0.24890D+00   0.69181D-01   0.62616D-01  -0.16772D+00
Cryo Cooler Pump                     8    -0.15981D+00  -0.45291D-01   0.24890D+00   0.69181D-01   0.62616D-01  -0.16772D+00
Cryo Cooler Pump                     8    -0.15981D+00  -0.45291D-01   0.24890D+00   0.69181D-01   0.62616D-01  -0.16772D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.10801D+00  -0.60112D-01  -0.10873D+00  -0.12710D+00   0.13565D-01  -0.12833D+00
Accelerometers                       7     0.10801D+00  -0.60112D-01  -0.10873D+00  -0.12710D+00   0.13565D-01  -0.12833D+00

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors            6     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors            6     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors            6     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors            6     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors            6     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Second Mirror                        9    -0.85482D-01  -0.13262D+00   0.25136D+00   0.68891D-01   0.60020D-01  -0.17021D+00
Second Mirror                        9    -0.85482D-01  -0.13262D+00   0.25136D+00   0.68891D-01   0.60020D-01  -0.17021D+00
Sensitive Instrument 2              10     0.26086D+00   0.11429D+00  -0.24707D+00  -0.14066D+00   0.74364D-02  -0.13042D+00
Sensitive Instrument 2              10     0.26086D+00   0.11429D+00  -0.24707D+00  -0.14066D+00   0.74364D-02  -0.13042D+00
Sensitive Instrument 3              11     0.12275D+00   0.52589D-01  -0.10757D+00  -0.12838D+00   0.90976D-02  -0.13010D+00
Sensitive Instrument 4              12     0.15589D+00   0.37186D-01  -0.14124D+00  -0.12886D+00   0.82267D-02  -0.12998D+00
Sensitive Instrument 5              13     0.15473D+00   0.27268D-01  -0.14071D+00  -0.12886D+00   0.82469D-02  -0.12997D+00

MODE# 44/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    440.02       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.37843D-01  -0.19914D-01   0.78387D-02   0.62198D-02   0.27690D-02   0.11027D-01
RCS Jet #2    (+X)                  22     0.41094D-02  -0.19778D-01   0.12087D-01  -0.14014D-02   0.47078D-02   0.55369D-01
RCS Jet #3    (+Y)                  23    -0.24023D-01  -0.14214D-02  -0.90800D-02  -0.28717D-02  -0.16926D-01   0.51472D-01
RCS Jet #4    (-Y)                  24     0.31446D-01  -0.74381D-03  -0.69378D-02  -0.41435D-02   0.25250D-01   0.51356D-01
RCS Jet #5    (-Y)                  25    -0.36113D-01   0.12015D-01   0.74757D-02  -0.30175D-02   0.26066D-02   0.57766D-01
RCS Jet #6    (+Y)                  26     0.37905D-01   0.14320D-01   0.10868D-01  -0.21499D-02   0.54925D-02   0.39174D-01
RCS Jet #7    (+X)                  27    -0.21554D-01  -0.93998D-01   0.32291D-02   0.94922D-01  -0.70187D-02   0.20388D+00
RCS Jet #8    (+X)                  28    -0.23896D-01  -0.12106D+00   0.33865D-02   0.94918D-01  -0.70219D-02   0.20390D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.24029D-01  -0.21285D-02   0.11427D-01   0.16584D-01   0.19033D-01   0.33917D-01
Reaction Wheel #2 Spin Axis         18    -0.44463D-03   0.32823D-01  -0.17609D-01   0.14964D-01   0.16955D-01   0.34651D-01
Reaction Wheel #3 Spin Axis         19    -0.31011D-01   0.18571D-01  -0.64468D-02  -0.15358D-01   0.37229D-02   0.39775D-01
Cryo Cooler Pump                     8    -0.31316D-01  -0.95379D-02  -0.18815D-01  -0.17921D-01   0.63442D-02  -0.43861D-01
Cryo Cooler Pump                     8    -0.31316D-01  -0.95379D-02  -0.18815D-01  -0.17921D-01   0.63442D-02  -0.43861D-01
Cryo Cooler Pump                     8    -0.31316D-01  -0.95379D-02  -0.18815D-01  -0.17921D-01   0.63442D-02  -0.43861D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.28918D-01  -0.25958D-01   0.17397D-02   0.96034D-02   0.12244D-01  -0.25184D-01
Accelerometers                       7     0.28918D-01  -0.25958D-01   0.17397D-02   0.96034D-02   0.12244D-01  -0.25184D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.13919D-01   0.18020D-02   0.68393D-02   0.91603D-02   0.84238D-02  -0.25576D-01
Inertial Attitude Sensors            6     0.13919D-01   0.18020D-02   0.68393D-02   0.91603D-02   0.84238D-02  -0.25576D-01
Inertial Attitude Sensors            6     0.13919D-01   0.18020D-02   0.68393D-02   0.91603D-02   0.84238D-02  -0.25576D-01
Inertial Attitude Sensors            6     0.13919D-01   0.18020D-02   0.68393D-02   0.91603D-02   0.84238D-02  -0.25576D-01
Inertial Attitude Sensors            6     0.13919D-01   0.18020D-02   0.68393D-02   0.91603D-02   0.84238D-02  -0.25576D-01
Inertial Attitude Sensors            6     0.13919D-01   0.18020D-02   0.68393D-02   0.91603D-02   0.84238D-02  -0.25576D-01
Second Mirror                        9    -0.23193D-01   0.11558D-01  -0.19296D-01  -0.17195D-01   0.62171D-02  -0.44164D-01
Second Mirror                        9    -0.23193D-01   0.11558D-01  -0.19296D-01  -0.17195D-01   0.62171D-02  -0.44164D-01
Sensitive Instrument 2              10     0.66610D-01  -0.20424D-01   0.22663D-01   0.14234D-01   0.13487D-01  -0.25193D-01
Sensitive Instrument 2              10     0.66610D-01  -0.20424D-01   0.22663D-01   0.14234D-01   0.13487D-01  -0.25193D-01
Sensitive Instrument 3              11     0.39140D-01  -0.34022D-01   0.38932D-02   0.10649D-01   0.10098D-01  -0.26761D-01
Sensitive Instrument 4              12     0.45987D-01  -0.37200D-01   0.53723D-02   0.10885D-01   0.10482D-01  -0.26670D-01
Sensitive Instrument 5              13     0.44505D-01  -0.33946D-01   0.60451D-02   0.10887D-01   0.10494D-01  -0.26672D-01

MODE# 45/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    453.24       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.66914D-01   0.35576D+00  -0.42135D-01   0.47634D-01  -0.69220D-02  -0.27007D-01
RCS Jet #2    (+X)                  22    -0.37299D-01  -0.17275D+00  -0.66891D-02   0.95656D-01   0.63775D-02  -0.70182D-01
RCS Jet #3    (+Y)                  23     0.31382D-01  -0.12460D+00  -0.14256D+00   0.75480D-01   0.16885D-01  -0.26977D-01
RCS Jet #4    (-Y)                  24    -0.95794D-01  -0.11966D+00   0.56237D-01   0.76319D-01  -0.23155D-01  -0.19476D-01
RCS Jet #5    (-Y)                  25    -0.30322D-01  -0.23019D+00   0.59333D-01   0.96904D-01   0.13170D-01   0.56734D-01
RCS Jet #6    (+Y)                  26    -0.12764D+00  -0.19997D+00  -0.82558D-01   0.10239D+00  -0.95623D-02  -0.18511D+00
RCS Jet #7    (+X)                  27    -0.11612D+00   0.70815D+00  -0.97842D-01  -0.84022D+00  -0.10013D+00  -0.15650D+01
RCS Jet #8    (+X)                  28    -0.14948D+00   0.95308D+00  -0.95597D-01  -0.84018D+00  -0.10016D+00  -0.15653D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.10682D+00   0.11476D+00  -0.14776D-01   0.51984D-01   0.70842D-02  -0.57158D-01
Reaction Wheel #2 Spin Axis         18    -0.15194D+00   0.19345D+00  -0.18952D+00   0.22164D+00   0.39568D-01  -0.63800D-01
Reaction Wheel #3 Spin Axis         19    -0.81393D-01   0.13040D+00   0.42089D-01   0.87400D-01  -0.61418D-01   0.79068D-01
Cryo Cooler Pump                     8     0.52311D-01  -0.15764D+00  -0.12853D+00  -0.22250D+00  -0.34228D-01   0.17424D+00
Cryo Cooler Pump                     8     0.52311D-01  -0.15764D+00  -0.12853D+00  -0.22250D+00  -0.34228D-01   0.17424D+00
Cryo Cooler Pump                     8     0.52311D-01  -0.15764D+00  -0.12853D+00  -0.22250D+00  -0.34228D-01   0.17424D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.44482D-01  -0.17248D+00  -0.67754D-02   0.57468D-01   0.23597D-01   0.55939D-01
Accelerometers                       7    -0.44482D-01  -0.17248D+00  -0.67754D-02   0.57468D-01   0.23597D-01   0.55939D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors            6    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors            6    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors            6    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors            6    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors            6    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Second Mirror                        9     0.93841D-02   0.98137D-01  -0.13420D+00  -0.20900D+00  -0.32869D-01   0.17896D+00
Second Mirror                        9     0.93841D-02   0.98137D-01  -0.13420D+00  -0.20900D+00  -0.32869D-01   0.17896D+00
Sensitive Instrument 2              10    -0.96235D-01  -0.29509D+00   0.91615D-01   0.10942D+00   0.30637D-01   0.69967D-01
Sensitive Instrument 2              10    -0.96235D-01  -0.29509D+00   0.91615D-01   0.10942D+00   0.30637D-01   0.69967D-01
Sensitive Instrument 3              11    -0.21818D-01  -0.25188D+00  -0.11366D-01   0.76163D-01   0.20614D-01   0.67478D-01
Sensitive Instrument 4              12    -0.38911D-01  -0.24388D+00   0.52798D-02   0.77047D-01   0.22368D-01   0.66953D-01
Sensitive Instrument 5              13    -0.42081D-01  -0.23725D+00   0.67147D-02   0.77062D-01   0.22361D-01   0.66930D-01

MODE# 46/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    470.95       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.81617D-02   0.88619D-01  -0.14114D-01  -0.43510D-02  -0.49331D-02  -0.28525D-01
RCS Jet #2    (+X)                  22    -0.22106D-01   0.35562D-01  -0.14714D-01   0.13781D-01  -0.53678D-02  -0.10885D+00
RCS Jet #3    (+Y)                  23     0.55119D-02  -0.36008D-01  -0.37594D-02   0.13434D-01   0.22001D-01  -0.82500D-01
RCS Jet #4    (-Y)                  24    -0.46961D-01  -0.35032D-01   0.13693D-01   0.14348D-01  -0.44191D-01  -0.76676D-01
RCS Jet #5    (-Y)                  25     0.48263D-01  -0.30069D-01  -0.59861D-03   0.15671D-01  -0.23284D-02  -0.88339D-01
RCS Jet #6    (+Y)                  26    -0.10077D+00  -0.27132D-01  -0.22887D-01   0.16246D-01  -0.90366D-02  -0.11232D+00
RCS Jet #7    (+X)                  27    -0.12182D-01   0.77351D+00  -0.31904D-01  -0.11139D+01  -0.27550D-01  -0.19118D+01
RCS Jet #8    (+X)                  28    -0.21359D-01   0.11019D+01  -0.31283D-01  -0.11139D+01  -0.27547D-01  -0.19121D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.54675D-03   0.31870D-01  -0.14944D-01  -0.32956D-01  -0.14105D-01  -0.95779D-01
Reaction Wheel #2 Spin Axis         18    -0.48293D-01  -0.17927D-01  -0.10539D-01   0.29674D-01  -0.28968D-01  -0.95242D-01
Reaction Wheel #3 Spin Axis         19     0.23831D-01  -0.39935D-01  -0.66629D-02   0.13770D-01   0.19814D-01  -0.97145D-01
Cryo Cooler Pump                     8     0.30381D-01  -0.56617D-02   0.19754D-01  -0.79860D-02   0.60133D-02   0.60254D-01
Cryo Cooler Pump                     8     0.30381D-01  -0.56617D-02   0.19754D-01  -0.79860D-02   0.60133D-02   0.60254D-01
Cryo Cooler Pump                     8     0.30381D-01  -0.56617D-02   0.19754D-01  -0.79860D-02   0.60133D-02   0.60254D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.45947D-01   0.28994D-02  -0.65599D-02  -0.95989D-02  -0.11186D-01   0.27983D-01
Accelerometers                       7    -0.45947D-01   0.28994D-02  -0.65599D-02  -0.95989D-02  -0.11186D-01   0.27983D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.28486D-01  -0.24744D-01  -0.67294D-02  -0.15912D-01  -0.44003D-02   0.28842D-01
Inertial Attitude Sensors            6    -0.28486D-01  -0.24744D-01  -0.67294D-02  -0.15912D-01  -0.44003D-02   0.28842D-01
Inertial Attitude Sensors            6    -0.28486D-01  -0.24744D-01  -0.67294D-02  -0.15912D-01  -0.44003D-02   0.28842D-01
Inertial Attitude Sensors            6    -0.28486D-01  -0.24744D-01  -0.67294D-02  -0.15912D-01  -0.44003D-02   0.28842D-01
Inertial Attitude Sensors            6    -0.28486D-01  -0.24744D-01  -0.67294D-02  -0.15912D-01  -0.44003D-02   0.28842D-01
Inertial Attitude Sensors            6    -0.28486D-01  -0.24744D-01  -0.67294D-02  -0.15912D-01  -0.44003D-02   0.28842D-01
Second Mirror                        9     0.37003D-01   0.43836D-02   0.19679D-01  -0.76000D-02   0.63018D-02   0.60522D-01
Second Mirror                        9     0.37003D-01   0.43836D-02   0.19679D-01  -0.76000D-02   0.63018D-02   0.60522D-01
Sensitive Instrument 2              10    -0.88097D-01  -0.10427D-01  -0.25369D-01  -0.89497D-02  -0.12358D-01   0.29208D-01
Sensitive Instrument 2              10    -0.88097D-01  -0.10427D-01  -0.25369D-01  -0.89497D-02  -0.12358D-01   0.29208D-01
Sensitive Instrument 3              11    -0.55031D-01   0.66169D-02  -0.10521D-01  -0.78622D-02  -0.87565D-02   0.31706D-01
Sensitive Instrument 4              12    -0.63142D-01   0.10391D-01  -0.11477D-01  -0.81028D-02  -0.91036D-02   0.31488D-01
Sensitive Instrument 5              13    -0.61856D-01   0.72219D-02  -0.12062D-01  -0.81036D-02  -0.91219D-02   0.31489D-01

MODE# 47/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.28643D+00  -0.46529D-01   0.49764D-02   0.17122D-01   0.96884D-02   0.43859D-01
RCS Jet #2    (+X)                  22     0.97349D-01  -0.16675D+00  -0.11903D+00   0.14801D-01  -0.81494D-01   0.19081D+00
RCS Jet #3    (+Y)                  23     0.81623D-01   0.90365D-01   0.19021D-01   0.28205D-02  -0.84468D-01   0.20050D+00
RCS Jet #4    (-Y)                  24     0.30035D-01   0.58941D-01   0.94213D-01   0.27331D-01  -0.28253D-02   0.90948D-01
RCS Jet #5    (-Y)                  25     0.25075D-01  -0.32306D-01  -0.65249D-01   0.77096D-02  -0.85565D-01   0.53760D-02
RCS Jet #6    (+Y)                  26     0.29114D+00  -0.78198D-01  -0.82012D-01   0.15419D-01  -0.74866D-01   0.36106D+00
RCS Jet #7    (+X)                  27     0.42510D+00  -0.17395D+01   0.24365D+00   0.27089D+01   0.39037D+00   0.44914D+01
RCS Jet #8    (+X)                  28     0.55521D+00  -0.25417D+01   0.23488D+00   0.27088D+01   0.39044D+00   0.44920D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.46577D+00   0.23185D-01  -0.16206D+00   0.95032D-02  -0.19060D+00   0.59422D-01
Reaction Wheel #2 Spin Axis         18     0.43979D+00   0.88562D-01   0.42703D-01  -0.11807D+00   0.15848D+00   0.47197D+00
Reaction Wheel #3 Spin Axis         19     0.29346D+00   0.31705D+00   0.19852D+00   0.18282D+00  -0.19433D+00   0.23518D+00
Cryo Cooler Pump                     8     0.50098D-01  -0.43365D-01  -0.10588D+00  -0.60721D-01  -0.77521D-02  -0.54463D-01
Cryo Cooler Pump                     8     0.50098D-01  -0.43365D-01  -0.10588D+00  -0.60721D-01  -0.77521D-02  -0.54463D-01
Cryo Cooler Pump                     8     0.50098D-01  -0.43365D-01  -0.10588D+00  -0.60721D-01  -0.77521D-02  -0.54463D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.96738D-02  -0.49379D-01   0.53737D-01   0.61807D-01  -0.48202D-01   0.68582D-02
Accelerometers                       7     0.96738D-02  -0.49379D-01   0.53737D-01   0.61807D-01  -0.48202D-01   0.68582D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors            6     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors            6     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors            6     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors            6     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors            6     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Second Mirror                        9     0.45158D-01   0.27638D-01  -0.10762D+00  -0.60060D-01  -0.55044D-02  -0.55657D-01
Second Mirror                        9     0.45158D-01   0.27638D-01  -0.10762D+00  -0.60060D-01  -0.55044D-02  -0.55657D-01
Sensitive Instrument 2              10    -0.37549D-01  -0.11436D+00   0.10520D+00   0.85062D-01  -0.42926D-01   0.81619D-02
Sensitive Instrument 2              10    -0.37549D-01  -0.11436D+00   0.10520D+00   0.85062D-01  -0.42926D-01   0.81619D-02
Sensitive Instrument 3              11    -0.34542D-01  -0.10954D+00   0.51546D-01   0.67608D-01  -0.49322D-01   0.70103D-02
Sensitive Instrument 4              12    -0.36274D-01  -0.10870D+00   0.74416D-01   0.68281D-01  -0.48029D-01   0.68154D-02
Sensitive Instrument 5              13    -0.29470D-01  -0.99456D-01   0.71333D-01   0.68287D-01  -0.48030D-01   0.68014D-02

MODE# 48/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    485.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.30326D+00   0.19028D+00  -0.55415D-01  -0.69617D-02  -0.12900D-01  -0.52806D-01
RCS Jet #2    (+X)                  22     0.62076D-02   0.38160D-01  -0.15313D+00   0.39982D-01  -0.84245D-01  -0.20600D+00
RCS Jet #3    (+Y)                  23     0.44991D-01  -0.54459D-01   0.32240D-01   0.27907D-01  -0.75286D-02  -0.10536D+00
RCS Jet #4    (-Y)                  24    -0.87288D-01  -0.75308D-01   0.98247D-01   0.49436D-01  -0.12928D+00  -0.16960D+00
RCS Jet #5    (-Y)                  25     0.18436D+00  -0.68894D-01  -0.75179D-01   0.40554D-01  -0.77885D-01  -0.29905D+00
RCS Jet #6    (+Y)                  26    -0.99585D-01  -0.96644D-01  -0.13637D+00   0.46657D-01  -0.88480D-01  -0.86646D-01
RCS Jet #7    (+X)                  27     0.32889D+00   0.44576D+01   0.95837D-01  -0.71251D+01   0.24359D+00  -0.11672D+02
RCS Jet #8    (+X)                  28     0.41009D+00   0.65706D+01   0.90367D-01  -0.71249D+01   0.24365D+00  -0.11673D+02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.42050D+00   0.12931D+00  -0.21439D+00  -0.16457D+00  -0.25099D+00  -0.36462D+00
Reaction Wheel #2 Spin Axis         18     0.23356D+00  -0.66835D-01   0.71264D-01  -0.10758D+00  -0.30534D-01   0.57498D-01
Reaction Wheel #3 Spin Axis         19     0.31533D+00   0.57092D-01   0.89571D-01   0.14418D+00  -0.12836D-01  -0.21688D+00
Cryo Cooler Pump                     8     0.97613D-01  -0.25174D-01   0.17121D-01  -0.39719D-01   0.32710D-01   0.83238D-01
Cryo Cooler Pump                     8     0.97613D-01  -0.25174D-01   0.17121D-01  -0.39719D-01   0.32710D-01   0.83238D-01
Cryo Cooler Pump                     8     0.97613D-01  -0.25174D-01   0.17121D-01  -0.39719D-01   0.32710D-01   0.83238D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.12548D+00  -0.17153D-01   0.11557D-01  -0.60940D-03  -0.82734D-01   0.65852D-01
Accelerometers                       7    -0.12548D+00  -0.17153D-01   0.11557D-01  -0.60940D-03  -0.82734D-01   0.65852D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors            6    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors            6    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors            6    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors            6    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors            6    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Second Mirror                        9     0.13909D+00   0.25846D-01   0.16491D-01  -0.40529D-01   0.34967D-01   0.81576D-01
Second Mirror                        9     0.13909D+00   0.25846D-01   0.16491D-01  -0.40529D-01   0.34967D-01   0.81576D-01
Sensitive Instrument 2              10    -0.27172D+00  -0.73748D-01  -0.38388D-01   0.11588D-01  -0.84546D-01   0.67642D-01
Sensitive Instrument 2              10    -0.27172D+00  -0.73748D-01  -0.38388D-01   0.11588D-01  -0.84546D-01   0.67642D-01
Sensitive Instrument 3              11    -0.19716D+00  -0.32729D-01  -0.36140D-02   0.77837D-02  -0.75822D-01   0.76262D-01
Sensitive Instrument 4              12    -0.21667D+00  -0.23622D-01   0.72763D-02   0.73082D-02  -0.76313D-01   0.75401D-01
Sensitive Instrument 5              13    -0.20588D+00  -0.27424D-01   0.23789D-02   0.73091D-02  -0.76373D-01   0.75397D-01

MODE# 49/ 49, Frequency (rad/sec), Damping (zeta), Generalized Mass=    495.00       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.80056D-02   0.18019D+00   0.64997D-02   0.91416D-02   0.14652D-03  -0.27660D-01
RCS Jet #2    (+X)                  22     0.21138D-02   0.15939D-01   0.43559D-02   0.67913D-02   0.10698D-02  -0.12924D-01
RCS Jet #3    (+Y)                  23     0.19699D-01   0.15693D-01  -0.29474D-01   0.23960D-01  -0.92880D-02  -0.29081D-01
RCS Jet #4    (-Y)                  24    -0.15585D-01   0.14442D-01   0.45620D-01   0.26467D-01  -0.26339D-02  -0.33908D-01
RCS Jet #5    (-Y)                  25     0.15870D-01   0.11550D-01   0.62733D-02   0.45565D-02  -0.82354D-02  -0.28592D-01
RCS Jet #6    (+Y)                  26    -0.19786D-03   0.73869D-02   0.18788D-02   0.29940D-02   0.12158D-01   0.46396D-02
RCS Jet #7    (+X)                  27     0.17613D-01  -0.14349D+02   0.48082D-01   0.24516D+02   0.58906D-01   0.39107D+02
RCS Jet #8    (+X)                  28     0.37241D-01  -0.21643D+02   0.46757D-01   0.24516D+02   0.58909D-01   0.39112D+02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.53314D-02   0.82050D-01   0.84144D-02   0.10489D-01   0.54372D-02  -0.75962D-02
Reaction Wheel #2 Spin Axis         18    -0.45242D-01   0.14205D+00  -0.70290D-01   0.10970D+00   0.37602D-01  -0.40282D-01
Reaction Wheel #3 Spin Axis         19     0.56741D-01   0.17395D+00   0.10679D+00   0.11232D+00  -0.11070D+00   0.60982D-01
Cryo Cooler Pump                     8     0.26260D-01  -0.24782D-01  -0.93977D-01  -0.22303D-01  -0.41064D-02   0.57761D-02
Cryo Cooler Pump                     8     0.26260D-01  -0.24782D-01  -0.93977D-01  -0.22303D-01  -0.41064D-02   0.57761D-02
Cryo Cooler Pump                     8     0.26260D-01  -0.24782D-01  -0.93977D-01  -0.22303D-01  -0.41064D-02   0.57761D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.73555D-02  -0.44452D-02   0.31425D-01   0.48383D-01   0.57899D-03   0.12727D-01
Accelerometers                       7    -0.73555D-02  -0.44452D-02   0.31425D-01   0.48383D-01   0.57899D-03   0.12727D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.11641D-02  -0.20414D-01   0.42757D-02   0.56198D-01  -0.64932D-03   0.12155D-01
Inertial Attitude Sensors            6    -0.11641D-02  -0.20414D-01   0.42757D-02   0.56198D-01  -0.64932D-03   0.12155D-01
Inertial Attitude Sensors            6    -0.11641D-02  -0.20414D-01   0.42757D-02   0.56198D-01  -0.64932D-03   0.12155D-01
Inertial Attitude Sensors            6    -0.11641D-02  -0.20414D-01   0.42757D-02   0.56198D-01  -0.64932D-03   0.12155D-01
Inertial Attitude Sensors            6    -0.11641D-02  -0.20414D-01   0.42757D-02   0.56198D-01  -0.64932D-03   0.12155D-01
Inertial Attitude Sensors            6    -0.11641D-02  -0.20414D-01   0.42757D-02   0.56198D-01  -0.64932D-03   0.12155D-01
Second Mirror                        9     0.22520D-01  -0.19734D-02  -0.94890D-01  -0.21881D-01  -0.32056D-02   0.58366D-02
Second Mirror                        9     0.22520D-01  -0.19734D-02  -0.94890D-01  -0.21881D-01  -0.32056D-02   0.58366D-02
Sensitive Instrument 2              10    -0.20363D-01  -0.52799D-01   0.92301D-01   0.59972D-01   0.59615D-02   0.13478D-01
Sensitive Instrument 2              10    -0.20363D-01  -0.52799D-01   0.92301D-01   0.59972D-01   0.59615D-02   0.13478D-01
Sensitive Instrument 3              11    -0.73465D-02  -0.46865D-01   0.32560D-01   0.49808D-01   0.11337D-02   0.11748D-01
Sensitive Instrument 4              12    -0.10304D-01  -0.45479D-01   0.45014D-01   0.50302D-01   0.20152D-02   0.11743D-01
Sensitive Instrument 5              13    -0.10590D-01  -0.39103D-01   0.45143D-01   0.50303D-01   0.20172D-02   0.11734D-01

MODE# 50/ 50, Frequency (rad/sec), Damping (zeta), Generalized Mass=    503.65       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.11824D+00   0.14329D+00  -0.66901D-01  -0.43585D-02  -0.22031D-01  -0.76586D-01
RCS Jet #2    (+X)                  22    -0.69028D-01   0.17309D+00  -0.76318D-01  -0.59756D-02  -0.29980D-01  -0.22388D+00
RCS Jet #3    (+Y)                  23    -0.10535D+00  -0.11569D+00   0.61199D-01  -0.15304D-01  -0.77429D-02  -0.17797D+00
RCS Jet #4    (-Y)                  24    -0.29523D-01  -0.11554D+00  -0.90643D-02  -0.10296D-01  -0.74058D-01  -0.16870D+00
RCS Jet #5    (-Y)                  25     0.78538D-01   0.39283D-01  -0.61318D-01  -0.37466D-02  -0.23614D-01  -0.19031D+00
RCS Jet #6    (+Y)                  26    -0.23466D+00   0.45649D-01  -0.57638D-01  -0.13915D-02  -0.37332D-01  -0.24256D+00
RCS Jet #7    (+X)                  27     0.27186D-01  -0.30887D+01  -0.87803D-01   0.55418D+01  -0.38122D-01   0.86597D+01
RCS Jet #8    (+X)                  28     0.14504D-01  -0.47416D+01  -0.86943D-01   0.55417D+01  -0.38111D-01   0.86609D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.10098D+00   0.19276D-01  -0.11455D+00  -0.13933D+00  -0.14059D+00  -0.30516D+00
Reaction Wheel #2 Spin Axis         18    -0.51261D-01  -0.22465D+00   0.84272D-01  -0.63588D-01  -0.20116D+00  -0.31706D+00
Reaction Wheel #3 Spin Axis         19     0.83709D-01  -0.29528D+00  -0.12412D+00  -0.30181D-01   0.22988D+00  -0.49484D+00
Cryo Cooler Pump                     8    -0.55428D-01   0.76952D-01   0.16331D+00   0.70836D-01   0.68712D-01  -0.47182D-01
Cryo Cooler Pump                     8    -0.55428D-01   0.76952D-01   0.16331D+00   0.70836D-01   0.68712D-01  -0.47182D-01
Cryo Cooler Pump                     8    -0.55428D-01   0.76952D-01   0.16331D+00   0.70836D-01   0.68712D-01  -0.47182D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.92644D-01   0.34018D-01  -0.46082D-01  -0.77814D-01  -0.46664D-01  -0.10244D-01
Accelerometers                       7    -0.92644D-01   0.34018D-01  -0.46082D-01  -0.77814D-01  -0.46664D-01  -0.10244D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors            6    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors            6    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors            6    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors            6    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
