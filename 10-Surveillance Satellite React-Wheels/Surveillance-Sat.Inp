Reaction Wheel #1 Spin Axis         17    -0.11158D+00   0.98965D-01   0.11969D+00  -0.32947D+00   0.23810D+00  -0.50581D+00
Reaction Wheel #2 Spin Axis         18    -0.36840D-01  -0.27907D-01   0.36522D-01   0.11596D-01  -0.24312D+00  -0.35461D+00
Reaction Wheel #3 Spin Axis         19     0.56999D-01   0.15865D-02   0.10958D-01   0.11058D+00   0.16260D+00  -0.32255D+00
Cryo Cooler Pump                     8    -0.41243D-01  -0.69019D-01  -0.15595D+00  -0.36230D-01  -0.17252D+00  -0.40492D+00
Cryo Cooler Pump                     8    -0.41243D-01  -0.69019D-01  -0.15595D+00  -0.36230D-01  -0.17252D+00  -0.40492D+00
Cryo Cooler Pump                     8    -0.41243D-01  -0.69019D-01  -0.15595D+00  -0.36230D-01  -0.17252D+00  -0.40492D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.40859D-02   0.21706D-01   0.75295D-02   0.74897D-02  -0.12638D-02   0.12901D-03
Accelerometers                       7    -0.40859D-02   0.21706D-01   0.75295D-02   0.74897D-02  -0.12638D-02   0.12901D-03

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.32653D-02   0.23664D-01   0.37884D-02  -0.69404D-03   0.39626D-03   0.23200D-02
Inertial Attitude Sensors            6    -0.32653D-02   0.23664D-01   0.37884D-02  -0.69404D-03   0.39626D-03   0.23200D-02
Inertial Attitude Sensors            6    -0.32653D-02   0.23664D-01   0.37884D-02  -0.69404D-03   0.39626D-03   0.23200D-02
Inertial Attitude Sensors            6    -0.32653D-02   0.23664D-01   0.37884D-02  -0.69404D-03   0.39626D-03   0.23200D-02
Inertial Attitude Sensors            6    -0.32653D-02   0.23664D-01   0.37884D-02  -0.69404D-03   0.39626D-03   0.23200D-02
Inertial Attitude Sensors            6    -0.32653D-02   0.23664D-01   0.37884D-02  -0.69404D-03   0.39626D-03   0.23200D-02
Second Mirror                        9    -0.24282D+00  -0.88421D-01  -0.15919D+00  -0.78132D-02  -0.17417D+00  -0.40850D+00
Second Mirror                        9    -0.24282D+00  -0.88421D-01  -0.15919D+00  -0.78132D-02  -0.17417D+00  -0.40850D+00
Sensitive Instrument 2              10    -0.41260D-02   0.14197D-01   0.14863D-01   0.62309D-02  -0.25889D-02  -0.29468D-02
Sensitive Instrument 2              10    -0.41260D-02   0.14197D-01   0.14863D-01   0.62309D-02  -0.25889D-02  -0.29468D-02
Sensitive Instrument 3              11    -0.70161D-02   0.11223D-01   0.72229D-02   0.79753D-02  -0.25145D-02  -0.26136D-02
Sensitive Instrument 4              12    -0.63569D-02   0.10914D-01   0.95649D-02   0.80006D-02  -0.24638D-02  -0.25872D-02
Sensitive Instrument 5              13    -0.60082D-02   0.12214D-01   0.94067D-02   0.79986D-02  -0.24655D-02  -0.25871D-02

MODE# 75/ 75, Frequency (rad/sec), Damping (zeta), Generalized Mass=    631.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.13278D-01   0.29319D-01  -0.37514D-02  -0.85608D-02  -0.77479D-02  -0.13452D-01
RCS Jet #2    (+X)                  22    -0.63772D-02   0.59093D-01   0.11673D-01  -0.14947D-01   0.34193D-02  -0.83723D-01
RCS Jet #3    (+Y)                  23    -0.48911D-02  -0.23168D-01   0.80094D-03   0.41588D-02  -0.47740D-02  -0.40968D-01
RCS Jet #4    (-Y)                  24    -0.35432D-02  -0.22458D-01  -0.86478D-03   0.50248D-02   0.41287D-03  -0.42782D-01
RCS Jet #5    (-Y)                  25     0.36730D-01   0.67100D-02  -0.44376D-02  -0.18985D-01  -0.11777D-01  -0.39581D-01
RCS Jet #6    (+Y)                  26    -0.78144D-01   0.17201D-01   0.23040D-01  -0.17376D-01   0.15212D-01  -0.12289D+00
RCS Jet #7    (+X)                  27    -0.66468D-01  -0.84793D-03  -0.96685D-01   0.13193D+00  -0.13790D+00   0.97969D-01
RCS Jet #8    (+X)                  28    -0.11241D+00  -0.42629D-01  -0.93581D-01   0.13193D+00  -0.13790D+00   0.97992D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.17594D+00  -0.10723D+00  -0.20994D+00   0.43327D+00  -0.42618D+00   0.69931D+00
Reaction Wheel #2 Spin Axis         18     0.46640D-01   0.83292D-02   0.38540D-01  -0.17860D+00   0.21299D+00   0.42949D+00
Reaction Wheel #3 Spin Axis         19    -0.13661D+00  -0.15939D-01  -0.83854D-01  -0.29803D+00  -0.18953D+00   0.49829D+00
Cryo Cooler Pump                     8     0.64921D-01  -0.53925D-01   0.26120D-01  -0.50102D-01   0.14072D+00   0.30781D+00
Cryo Cooler Pump                     8     0.64921D-01  -0.53925D-01   0.26120D-01  -0.50102D-01   0.14072D+00   0.30781D+00
Cryo Cooler Pump                     8     0.64921D-01  -0.53925D-01   0.26120D-01  -0.50102D-01   0.14072D+00   0.30781D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.66951D-02  -0.72280D-02   0.57207D-02   0.97307D-02   0.17200D-01   0.17323D-02
Accelerometers                       7     0.66951D-02  -0.72280D-02   0.57207D-02   0.97307D-02   0.17200D-01   0.17323D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors            6     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors            6     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors            6     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors            6     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors            6     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Second Mirror                        9     0.23107D+00   0.12942D-01   0.25702D-01  -0.54164D-01   0.14221D+00   0.30733D+00
Second Mirror                        9     0.23107D+00   0.12942D-01   0.25702D-01  -0.54164D-01   0.14221D+00   0.30733D+00
Sensitive Instrument 2              10     0.17954D-01  -0.19061D-01   0.33325D-01   0.17400D-01   0.19920D-01   0.51137D-02
Sensitive Instrument 2              10     0.17954D-01  -0.19061D-01   0.33325D-01   0.17400D-01   0.19920D-01   0.51137D-02
Sensitive Instrument 3              11     0.21782D-01  -0.16044D-01   0.87363D-02   0.11375D-01   0.15770D-01   0.21574D-02
Sensitive Instrument 4              12     0.21267D-01  -0.15809D-01   0.97210D-02   0.11730D-01   0.16309D-01   0.23339D-02
Sensitive Instrument 5              13     0.18959D-01  -0.14295D-01   0.10768D-01   0.11731D-01   0.16321D-01   0.23298D-02

MODE# 76/ 76, Frequency (rad/sec), Damping (zeta), Generalized Mass=    632.95       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.36825D-01   0.11228D+00  -0.86293D-02   0.78869D-02  -0.30568D-01   0.37218D-01
RCS Jet #2    (+X)                  22     0.23330D-02   0.25111D+00   0.31901D-01  -0.76127D-01   0.22903D-01  -0.36214D+00
RCS Jet #3    (+Y)                  23     0.24108D-02  -0.13998D+00   0.28320D-01   0.15208D-01  -0.17464D-02  -0.27131D+00
RCS Jet #4    (-Y)                  24     0.32663D-01  -0.11883D+00  -0.72643D-02  -0.82639D-02   0.35099D-01  -0.19477D+00
RCS Jet #5    (-Y)                  25     0.23303D+00   0.40048D-01  -0.47583D-01  -0.88361D-01  -0.31200D-01  -0.29874D+00
RCS Jet #6    (+Y)                  26    -0.28264D+00   0.60642D-01   0.87334D-01  -0.94123D-01   0.77788D-01  -0.45766D+00
RCS Jet #7    (+X)                  27    -0.41511D+00   0.39020D-01  -0.83221D+00   0.24880D+00  -0.11433D+01   0.49607D-01
RCS Jet #8    (+X)                  28    -0.79598D+00  -0.42807D-01  -0.80646D+00   0.24878D+00  -0.11432D+01   0.49640D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.92321D+00  -0.82224D+00  -0.10602D+01   0.28482D+01  -0.22121D+01   0.45404D+01
Reaction Wheel #2 Spin Axis         18    -0.25087D+00  -0.36148D+00   0.23215D+00  -0.14802D+00  -0.92477D+00  -0.12971D+01
Reaction Wheel #3 Spin Axis         19    -0.50487D+00   0.75315D-02  -0.15131D+00  -0.97740D+00  -0.11961D+01   0.24240D+01
Cryo Cooler Pump                     8    -0.14584D-01   0.16312D-01  -0.24025D-02   0.20248D-02  -0.71430D-01  -0.10442D+00
Cryo Cooler Pump                     8    -0.14584D-01   0.16312D-01  -0.24025D-02   0.20248D-02  -0.71430D-01  -0.10442D+00
Cryo Cooler Pump                     8    -0.14584D-01   0.16312D-01  -0.24025D-02   0.20248D-02  -0.71430D-01  -0.10442D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.22136D-01  -0.78093D-02   0.43186D-01   0.10045D-01   0.33640D-03  -0.19957D-02
Accelerometers                       7     0.22136D-01  -0.78093D-02   0.43186D-01   0.10045D-01   0.33640D-03  -0.19957D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors            6     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors            6     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors            6     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors            6     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors            6     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Second Mirror                        9    -0.99289D-01   0.12389D-01  -0.26669D-02   0.60408D-02  -0.71382D-01  -0.10164D+00
Second Mirror                        9    -0.99289D-01   0.12389D-01  -0.26669D-02   0.60408D-02  -0.71382D-01  -0.10164D+00
Sensitive Instrument 2              10     0.24249D-01  -0.20608D-01   0.60909D-01   0.13793D-01   0.48001D-03   0.11554D-02
Sensitive Instrument 2              10     0.24249D-01  -0.20608D-01   0.60909D-01   0.13793D-01   0.48001D-03   0.11554D-02
Sensitive Instrument 3              11     0.22286D-01  -0.19143D-01   0.47340D-01   0.87580D-02  -0.27224D-02  -0.17772D-02
Sensitive Instrument 4              12     0.22761D-01  -0.19390D-01   0.49833D-01   0.92329D-02  -0.21799D-02  -0.12606D-02
Sensitive Instrument 5              13     0.23074D-01  -0.18000D-01   0.49693D-01   0.92352D-02  -0.21589D-02  -0.12640D-02

MODE# 77/ 77, Frequency (rad/sec), Damping (zeta), Generalized Mass=    635.94       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.86533D-01  -0.22196D-01  -0.14273D-01  -0.97165D-02  -0.18804D-01   0.17681D-01
RCS Jet #2    (+X)                  22    -0.11806D-01   0.92195D-01   0.27117D-02  -0.39340D-01  -0.24083D-01  -0.10917D+00
RCS Jet #3    (+Y)                  23     0.14619D-02   0.15762D-01   0.27767D-01   0.10723D-02  -0.27373D-01  -0.59653D-01
RCS Jet #4    (-Y)                  24    -0.42815D-01   0.19446D-01   0.14825D-01   0.24097D-02  -0.26191D-01  -0.60508D-01
RCS Jet #5    (-Y)                  25     0.28988D-01   0.19494D-01  -0.20320D-01  -0.52470D-01  -0.56652D-01  -0.89393D-02
RCS Jet #6    (+Y)                  26    -0.12850D+00   0.46709D-01   0.47678D-01  -0.39632D-01  -0.67702D-02  -0.22865D+00
RCS Jet #7    (+X)                  27    -0.20634D+00   0.40762D-01  -0.44762D+00  -0.15652D-01  -0.61574D+00  -0.11037D+00
RCS Jet #8    (+X)                  28    -0.41148D+00   0.43499D-01  -0.43376D+00  -0.15649D-01  -0.61574D+00  -0.11038D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.27005D+00  -0.27016D+00  -0.30632D+00   0.10083D+01  -0.70338D+00   0.16457D+01
Reaction Wheel #2 Spin Axis         18    -0.20183D+00  -0.24615D+00   0.22205D+00  -0.58880D-01  -0.10529D+01  -0.14836D+01
Reaction Wheel #3 Spin Axis         19    -0.12969D+00  -0.25760D-01  -0.64328D-01  -0.26388D+00  -0.17452D+00   0.42307D+00
Cryo Cooler Pump                     8     0.40730D+00  -0.34120D+00   0.86842D-01  -0.30064D+00   0.77863D+00   0.16166D+01
Cryo Cooler Pump                     8     0.40730D+00  -0.34120D+00   0.86842D-01  -0.30064D+00   0.77863D+00   0.16166D+01
Cryo Cooler Pump                     8     0.40730D+00  -0.34120D+00   0.86842D-01  -0.30064D+00   0.77863D+00   0.16166D+01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.28140D-02   0.27789D-01   0.74573D-02   0.22928D-01   0.53153D-01   0.20864D-01
Accelerometers                       7     0.28140D-02   0.27789D-01   0.74573D-02   0.22928D-01   0.53153D-01   0.20864D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors            6     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors            6     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors            6     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors            6     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors            6     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Second Mirror                        9     0.13303D+01   0.35366D-02   0.82462D-01  -0.29623D+00   0.78583D+00   0.16032D+01
Second Mirror                        9     0.13303D+01   0.35366D-02   0.82462D-01  -0.29623D+00   0.78583D+00   0.16032D+01
Sensitive Instrument 2              10     0.21519D-01   0.73857D-02   0.74730D-01   0.27086D-01   0.57953D-01   0.28172D-01
Sensitive Instrument 2              10     0.21519D-01   0.73857D-02   0.74730D-01   0.27086D-01   0.57953D-01   0.28172D-01
Sensitive Instrument 3              11     0.49170D-01   0.18158D-01   0.15113D-01   0.23945D-01   0.52300D-01   0.21283D-01
Sensitive Instrument 4              12     0.43790D-01   0.20626D-01   0.15042D-01   0.24437D-01   0.52921D-01   0.21816D-01
Sensitive Instrument 5              13     0.36298D-01   0.22689D-01   0.18438D-01   0.24431D-01   0.52945D-01   0.21814D-01

MODE# 78/ 78, Frequency (rad/sec), Damping (zeta), Generalized Mass=    647.55       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.11365D+00   0.31255D-01   0.11667D-01   0.22644D-01  -0.97147D-02   0.26232D-02
RCS Jet #2    (+X)                  22     0.23907D-01  -0.29067D+00  -0.11688D-01   0.67200D-01  -0.74219D-02   0.34794D+00
RCS Jet #3    (+Y)                  23     0.94390D-01   0.17240D+00  -0.47417D-01   0.10467D-01  -0.49013D-02   0.21436D+00
RCS Jet #4    (-Y)                  24    -0.46366D-01   0.17112D+00   0.31553D-01   0.13186D-01   0.17032D-02   0.21872D+00
RCS Jet #5    (-Y)                  25    -0.21692D+00  -0.92275D-01   0.47202D-01   0.73027D-01   0.26578D-01   0.33842D+00
RCS Jet #6    (+Y)                  26     0.25538D+00  -0.89585D-01  -0.62714D-01   0.74444D-01  -0.43121D-01   0.31260D+00
RCS Jet #7    (+X)                  27    -0.49429D-01   0.45862D-01  -0.20942D+00  -0.49610D+00  -0.28682D+00  -0.40390D+00
RCS Jet #8    (+X)                  28    -0.14497D+00   0.20218D+00  -0.20295D+00  -0.49609D+00  -0.28676D+00  -0.40399D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.40271D+00  -0.42379D+00  -0.43750D+00   0.15864D+01  -0.91822D+00   0.26130D+01
Reaction Wheel #2 Spin Axis         18    -0.27776D+00  -0.58305D+00   0.48753D+00  -0.49346D-01  -0.27420D+01  -0.36932D+01
Reaction Wheel #3 Spin Axis         19     0.46940D+00  -0.38360D-01   0.17478D+00   0.13168D+01   0.14047D+01  -0.29887D+01
Cryo Cooler Pump                     8    -0.18112D+00   0.24736D+00  -0.10875D+00   0.22266D+00  -0.58728D+00  -0.98983D+00
Cryo Cooler Pump                     8    -0.18112D+00   0.24736D+00  -0.10875D+00   0.22266D+00  -0.58728D+00  -0.98983D+00
Cryo Cooler Pump                     8    -0.18112D+00   0.24736D+00  -0.10875D+00   0.22266D+00  -0.58728D+00  -0.98983D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.13296D-01   0.31586D-01   0.22162D-01   0.11440D-01  -0.17564D-01   0.38774D-01
Accelerometers                       7    -0.13296D-01   0.31586D-01   0.22162D-01   0.11440D-01  -0.17564D-01   0.38774D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors            6     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors            6     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors            6     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors            6     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors            6     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Second Mirror                        9    -0.87865D+00  -0.13338D-01  -0.10604D+00   0.21884D+00  -0.59000D+00  -0.97292D+00
Second Mirror                        9    -0.87865D+00  -0.13338D-01  -0.10604D+00   0.21884D+00  -0.59000D+00  -0.97292D+00
Sensitive Instrument 2              10    -0.70679D-01   0.24427D-02   0.19725D-01   0.65849D-02  -0.19583D-01   0.37828D-01
Sensitive Instrument 2              10    -0.70679D-01   0.24427D-02   0.19725D-01   0.65849D-02  -0.19583D-01   0.37828D-01
Sensitive Instrument 3              11    -0.30568D-01   0.21366D-01   0.19264D-01   0.82416D-02  -0.15373D-01   0.38671D-01
Sensitive Instrument 4              12    -0.40462D-01   0.25955D-01   0.23217D-01   0.80747D-02  -0.15661D-01   0.38603D-01
Sensitive Instrument 5              13    -0.38247D-01   0.24622D-01   0.22212D-01   0.80693D-02  -0.15679D-01   0.38605D-01

MODE# 79/ 79, Frequency (rad/sec), Damping (zeta), Generalized Mass=    651.44       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.12818D+00   0.11644D+00  -0.53760D-01   0.26735D-01  -0.24542D-03   0.49483D-01
RCS Jet #2    (+X)                  22     0.27181D-01  -0.14668D+00  -0.20004D-01   0.22202D-01   0.23984D-01   0.14674D+00
RCS Jet #3    (+Y)                  23     0.78520D-01   0.70486D-01  -0.57816D-01   0.23533D-01   0.24334D-01   0.69418D-01
RCS Jet #4    (-Y)                  24    -0.25248D-02   0.84343D-01  -0.30678D-02   0.74230D-02   0.22451D-03   0.11631D+00
RCS Jet #5    (-Y)                  25    -0.88955D-01  -0.67786D-01  -0.13208D-01   0.30761D-01   0.38113D-01   0.18419D+00
RCS Jet #6    (+Y)                  26     0.13266D+00  -0.63555D-01  -0.48459D-01   0.17483D-01   0.21228D-01   0.15290D+00
RCS Jet #7    (+X)                  27     0.30718D+00   0.10378D+00   0.61150D+00  -0.28280D+00   0.88810D+00  -0.37115D+00
RCS Jet #8    (+X)                  28     0.60305D+00   0.18972D+00   0.59149D+00  -0.28279D+00   0.88801D+00  -0.37121D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.33210D+00   0.34662D+00   0.24154D+00  -0.10340D+01   0.55445D+00  -0.15550D+01
Reaction Wheel #2 Spin Axis         18    -0.17203D+00  -0.46449D+00   0.46155D+00  -0.40241D+00  -0.21199D+01  -0.26290D+01
Reaction Wheel #3 Spin Axis         19    -0.12926D+01  -0.20353D+00  -0.10532D+01  -0.34560D+01  -0.15606D+01   0.52278D+01
Cryo Cooler Pump                     8    -0.66404D-01   0.95282D-01  -0.86432D-01   0.10210D+00  -0.34435D+00  -0.51967D+00
Cryo Cooler Pump                     8    -0.66404D-01   0.95282D-01  -0.86432D-01   0.10210D+00  -0.34435D+00  -0.51967D+00
Cryo Cooler Pump                     8    -0.66404D-01   0.95282D-01  -0.86432D-01   0.10210D+00  -0.34435D+00  -0.51967D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.14410D-01   0.18922D-01  -0.34252D-01  -0.71906D-02  -0.20870D-01   0.25205D-01
Accelerometers                       7     0.14410D-01   0.18922D-01  -0.34252D-01  -0.71906D-02  -0.20870D-01   0.25205D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors            6     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors            6     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors            6     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors            6     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors            6     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Second Mirror                        9    -0.47527D+00  -0.34533D-01  -0.85425D-01   0.10268D+00  -0.34494D+00  -0.50808D+00
Second Mirror                        9    -0.47527D+00  -0.34533D-01  -0.85425D-01   0.10268D+00  -0.34494D+00  -0.50808D+00
Sensitive Instrument 2              10    -0.28917D-01   0.73333D-02  -0.61974D-01  -0.71504D-02  -0.23470D-01   0.29002D-01
Sensitive Instrument 2              10    -0.28917D-01   0.73333D-02  -0.61974D-01  -0.71504D-02  -0.23470D-01   0.29002D-01
Sensitive Instrument 3              11    -0.22141D-02   0.20771D-01  -0.38865D-01  -0.61284D-02  -0.21109D-01   0.27714D-01
Sensitive Instrument 4              12    -0.92618D-02   0.24075D-01  -0.37862D-01  -0.65453D-02  -0.21518D-01   0.27188D-01
Sensitive Instrument 5              13    -0.62158D-02   0.21403D-01  -0.39242D-01  -0.65494D-02  -0.21530D-01   0.27192D-01

MODE# 80/ 80, Frequency (rad/sec), Damping (zeta), Generalized Mass=    657.68       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.78988D-01  -0.17577D-01  -0.96924D-01   0.99584D-03  -0.12072D+00  -0.21670D-01
RCS Jet #2    (+X)                  22    -0.14315D-01  -0.88863D-02   0.14079D-01   0.45240D-02   0.20086D-01   0.54653D-01
RCS Jet #3    (+Y)                  23    -0.17841D-01  -0.31329D-02   0.27871D-02  -0.47329D-02  -0.57047D-02   0.11325D-01
RCS Jet #4    (-Y)                  24     0.28512D-01   0.27688D-02  -0.56069D-02  -0.10268D-01   0.35274D-02   0.24826D-01
RCS Jet #5    (-Y)                  25    -0.88212D-01   0.83925D-02   0.88659D-02   0.94790D-02   0.28510D-01   0.15901D+00
RCS Jet #6    (+Y)                  26    -0.10969D-01   0.34594D-01  -0.16657D-02   0.40202D-02   0.11522D-01  -0.46649D-01
RCS Jet #7    (+X)                  27    -0.28165D-01  -0.13417D-01  -0.11940D+00  -0.14161D-01  -0.14627D+00   0.26474D-01
RCS Jet #8    (+X)                  28    -0.76887D-01  -0.81010D-02  -0.11611D+00  -0.14162D-01  -0.14628D+00   0.26476D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.52186D-01   0.35201D-02   0.46948D-02  -0.91343D-01  -0.79616D-02  -0.14202D+00
Reaction Wheel #2 Spin Axis         18     0.12866D-01   0.40022D-01  -0.36405D-01  -0.14503D-01   0.25390D+00   0.38902D+00
Reaction Wheel #3 Spin Axis         19     0.43909D-01   0.29291D-02   0.70062D-01   0.24845D+00   0.68735D-01  -0.32104D+00
Cryo Cooler Pump                     8     0.25580D-01  -0.42227D-01   0.15679D-01  -0.34456D-01   0.11608D+00   0.19048D+00
Cryo Cooler Pump                     8     0.25580D-01  -0.42227D-01   0.15679D-01  -0.34456D-01   0.11608D+00   0.19048D+00
Cryo Cooler Pump                     8     0.25580D-01  -0.42227D-01   0.15679D-01  -0.34456D-01   0.11608D+00   0.19048D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.26943D-01   0.21577D-04  -0.12855D-01  -0.33953D-02   0.16004D-01  -0.18802D-01
Accelerometers                       7     0.26943D-01   0.21577D-04  -0.12855D-01  -0.33953D-02   0.16004D-01  -0.18802D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.14993D-01   0.19778D-01   0.19089D-02  -0.40583D-02   0.11028D-01  -0.18203D-01
Inertial Attitude Sensors            6     0.14993D-01   0.19778D-01   0.19089D-02  -0.40583D-02   0.11028D-01  -0.18203D-01
Inertial Attitude Sensors            6     0.14993D-01   0.19778D-01   0.19089D-02  -0.40583D-02   0.11028D-01  -0.18203D-01
Inertial Attitude Sensors            6     0.14993D-01   0.19778D-01   0.19089D-02  -0.40583D-02   0.11028D-01  -0.18203D-01
Inertial Attitude Sensors            6     0.14993D-01   0.19778D-01   0.19089D-02  -0.40583D-02   0.11028D-01  -0.18203D-01
Inertial Attitude Sensors            6     0.14993D-01   0.19778D-01   0.19089D-02  -0.40583D-02   0.11028D-01  -0.18203D-01
Second Mirror                        9     0.16287D+00  -0.25445D-02   0.15441D-01  -0.34097D-01   0.11625D+00   0.18754D+00
Second Mirror                        9     0.16287D+00  -0.25445D-02   0.15441D-01  -0.34097D-01   0.11625D+00   0.18754D+00
Sensitive Instrument 2              10     0.65572D-01   0.19795D-01  -0.72381D-02  -0.75374D-02   0.16367D-01  -0.18200D-01
Sensitive Instrument 2              10     0.65572D-01   0.19795D-01  -0.72381D-02  -0.75374D-02   0.16367D-01  -0.18200D-01
Sensitive Instrument 3              11     0.43143D-01   0.78050D-02  -0.83803D-02  -0.53002D-02   0.13114D-01  -0.21608D-01
Sensitive Instrument 4              12     0.48688D-01   0.52172D-02  -0.11252D-01  -0.51746D-02   0.13247D-01  -0.21334D-01
Sensitive Instrument 5              13     0.46817D-01   0.58524D-02  -0.10401D-01  -0.51746D-02   0.13272D-01  -0.21332D-01

MODE# 81/ 81, Frequency (rad/sec), Damping (zeta), Generalized Mass=    658.83       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.26008D+00  -0.34327D-01   0.25974D+00  -0.76205D-02   0.34352D+00   0.17405D-01
RCS Jet #2    (+X)                  22    -0.20137D-02   0.16281D-01   0.86772D-02  -0.13577D-01  -0.13882D-01  -0.37364D-01
RCS Jet #3    (+Y)                  23    -0.32712D-02   0.11019D-02   0.59201D-02  -0.30271D-02  -0.11842D-01  -0.10700D-01
RCS Jet #4    (-Y)                  24    -0.25943D-01  -0.36785D-02   0.10386D-03   0.24235D-02   0.63488D-02  -0.22290D-01
RCS Jet #5    (-Y)                  25     0.36503D-01   0.82264D-03   0.27106D-02  -0.20500D-01  -0.26975D-01  -0.75094D-01
RCS Jet #6    (+Y)                  26    -0.18974D-01  -0.76753D-02   0.27096D-01  -0.12476D-01  -0.66606D-02  -0.11480D-01
RCS Jet #7    (+X)                  27    -0.28909D-01   0.33958D-01   0.26047D+00  -0.94396D-01   0.31228D+00  -0.15253D+00
RCS Jet #8    (+X)                  28     0.75106D-01   0.62000D-01   0.25345D+00  -0.94391D-01   0.31229D+00  -0.15254D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.21960D+00  -0.87751D-01  -0.18344D+00   0.30536D+00  -0.34106D+00   0.48486D+00
Reaction Wheel #2 Spin Axis         18    -0.82255D-02  -0.12980D-01   0.42382D-02   0.34836D-01  -0.38342D-01  -0.94939D-01
Reaction Wheel #3 Spin Axis         19     0.10910D+00   0.24636D-01   0.86696D-01   0.26706D+00   0.12476D+00  -0.40204D+00
Cryo Cooler Pump                     8    -0.24664D-01   0.23865D-01  -0.11241D-01   0.17634D-01  -0.55488D-01  -0.10466D+00
Cryo Cooler Pump                     8    -0.24664D-01   0.23865D-01  -0.11241D-01   0.17634D-01  -0.55488D-01  -0.10466D+00
Cryo Cooler Pump                     8    -0.24664D-01   0.23865D-01  -0.11241D-01   0.17634D-01  -0.55488D-01  -0.10466D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.15394D-01  -0.14038D-02   0.22119D-01   0.10721D-01   0.74135D-02   0.78362D-02
Accelerometers                       7    -0.15394D-01  -0.14038D-02   0.22119D-01   0.10721D-01   0.74135D-02   0.78362D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.12262D-01  -0.11140D-01   0.22877D-01   0.15428D-01   0.45370D-02   0.72967D-02
Inertial Attitude Sensors            6    -0.12262D-01  -0.11140D-01   0.22877D-01   0.15428D-01   0.45370D-02   0.72967D-02
Inertial Attitude Sensors            6    -0.12262D-01  -0.11140D-01   0.22877D-01   0.15428D-01   0.45370D-02   0.72967D-02
Inertial Attitude Sensors            6    -0.12262D-01  -0.11140D-01   0.22877D-01   0.15428D-01   0.45370D-02   0.72967D-02
Inertial Attitude Sensors            6    -0.12262D-01  -0.11140D-01   0.22877D-01   0.15428D-01   0.45370D-02   0.72967D-02
Inertial Attitude Sensors            6    -0.12262D-01  -0.11140D-01   0.22877D-01   0.15428D-01   0.45370D-02   0.72967D-02
Second Mirror                        9    -0.90597D-01   0.38614D-02  -0.11137D-01   0.17623D-01  -0.55862D-01  -0.10318D+00
Second Mirror                        9    -0.90597D-01   0.38614D-02  -0.11137D-01   0.17623D-01  -0.55862D-01  -0.10318D+00
Sensitive Instrument 2              10    -0.20402D-01  -0.16943D-01   0.42901D-01   0.14321D-01   0.91428D-02   0.72502D-02
Sensitive Instrument 2              10    -0.20402D-01  -0.16943D-01   0.42901D-01   0.14321D-01   0.91428D-02   0.72502D-02
Sensitive Instrument 3              11    -0.10873D-01  -0.11694D-01   0.23156D-01   0.10715D-01   0.83629D-02   0.76231D-02
Sensitive Instrument 4              12    -0.12826D-01  -0.10797D-01   0.24849D-01   0.10949D-01   0.86508D-02   0.77816D-02
Sensitive Instrument 5              13    -0.14052D-01  -0.97438D-02   0.25404D-01   0.10949D-01   0.86484D-02   0.77784D-02

MODE# 82/ 82, Frequency (rad/sec), Damping (zeta), Generalized Mass=    662.07       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.18725D+00  -0.46696D-01  -0.28952D-01   0.19027D-01   0.52244D-01  -0.74125D-01
RCS Jet #2    (+X)                  22    -0.66646D-01  -0.17238D+00   0.70147D-01   0.43618D-01   0.80501D-01   0.42454D+00
RCS Jet #3    (+Y)                  23    -0.34018D-01   0.12400D+00  -0.59515D-01   0.40922D-02  -0.11416D-01   0.16610D+00
RCS Jet #4    (-Y)                  24     0.69938D-01   0.15454D+00  -0.42706D-02  -0.21404D-01   0.92731D-02   0.24943D+00
RCS Jet #5    (-Y)                  25    -0.55491D+00  -0.22913D-02   0.66920D-01   0.60569D-01   0.11612D+00   0.97884D+00
RCS Jet #6    (+Y)                  26     0.40617D-01   0.13765D+00  -0.14147D-01   0.46022D-01   0.31654D-01  -0.12919D+00
RCS Jet #7    (+X)                  27    -0.65693D-01  -0.26336D-01   0.13071D+00  -0.21316D+00   0.22225D+00  -0.68207D-02
RCS Jet #8    (+X)                  28     0.83451D-02   0.44571D-01   0.12568D+00  -0.21314D+00   0.22214D+00  -0.68452D-02

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.91368D-01  -0.69757D-01  -0.34757D+00   0.19010D+00  -0.72778D+00   0.40271D+00
Reaction Wheel #2 Spin Axis         18    -0.18213D-01  -0.15418D+00   0.24802D+00  -0.48200D+00  -0.47274D+00  -0.11048D+00
Reaction Wheel #3 Spin Axis         19     0.35541D-01  -0.51050D-02   0.76130D-01   0.70841D+00   0.60930D+00  -0.14303D+01
Cryo Cooler Pump                     8     0.23263D-01  -0.18011D+00  -0.11850D+00  -0.96451D-01   0.15316D+00   0.24422D+00
Cryo Cooler Pump                     8     0.23263D-01  -0.18011D+00  -0.11850D+00  -0.96451D-01   0.15316D+00   0.24422D+00
Cryo Cooler Pump                     8     0.23263D-01  -0.18011D+00  -0.11850D+00  -0.96451D-01   0.15316D+00   0.24422D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.11721D+00   0.28458D-01  -0.19285D-01   0.32824D-01   0.10254D+00  -0.56500D-01
Accelerometers                       7     0.11721D+00   0.28458D-01  -0.19285D-01   0.32824D-01   0.10254D+00  -0.56500D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors            6     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors            6     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors            6     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors            6     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors            6     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Second Mirror                        9     0.20292D+00  -0.11652D+00  -0.11675D+00  -0.72901D-01   0.15421D+00   0.24719D+00
Second Mirror                        9     0.20292D+00  -0.11652D+00  -0.11675D+00  -0.72901D-01   0.15421D+00   0.24719D+00
Sensitive Instrument 2              10     0.28511D+00   0.54712D-01   0.94014D-01   0.32579D-01   0.11086D+00  -0.50422D-01
Sensitive Instrument 2              10     0.28511D+00   0.54712D-01   0.94014D-01   0.32579D-01   0.11086D+00  -0.50422D-01
Sensitive Instrument 3              11     0.21330D+00   0.16352D-01   0.66864D-02   0.27184D-01   0.86222D-01  -0.72904D-01
Sensitive Instrument 4              12     0.23213D+00   0.75433D-02   0.34309D-02   0.28772D-01   0.88439D-01  -0.71237D-01
Sensitive Instrument 5              13     0.21963D+00   0.16193D-01   0.91070D-02   0.28770D-01   0.88571D-01  -0.71242D-01

MODE# 83/ 83, Frequency (rad/sec), Damping (zeta), Generalized Mass=    665.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.35337D-01   0.15436D+00  -0.19836D-02   0.25993D-01   0.17176D-01  -0.21371D-01
RCS Jet #2    (+X)                  22    -0.21179D-01  -0.14299D+00   0.35237D-01   0.65126D-01   0.43604D-01   0.24607D+00
RCS Jet #3    (+Y)                  23    -0.26569D-01  -0.90687D-02  -0.22410D-01   0.90335D-03   0.27289D-01   0.59069D-01
RCS Jet #4    (-Y)                  24     0.48690D-01   0.10253D-02   0.26814D-02  -0.11436D-01  -0.12212D-01   0.75434D-01
RCS Jet #5    (-Y)                  25    -0.25904D+00  -0.31032D-01   0.70274D-01   0.83375D-01   0.92576D-01   0.44155D+00
RCS Jet #6    (+Y)                  26     0.88983D-01   0.16127D-01  -0.45147D-01   0.71240D-01  -0.42379D-02   0.69797D-01
RCS Jet #7    (+X)                  27     0.25727D-01  -0.92915D-01   0.16436D+00   0.88624D-01   0.23032D+00   0.30967D+00
RCS Jet #8    (+X)                  28     0.10245D+00  -0.11550D+00   0.15916D+00   0.88615D-01   0.23028D+00   0.30971D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.49421D-01  -0.84158D-01  -0.14134D+00   0.11851D+00  -0.28183D+00   0.16892D+00
Reaction Wheel #2 Spin Axis         18    -0.10721D-01  -0.44467D-01  -0.21745D-01   0.26269D-01   0.36082D-01   0.11072D+00
Reaction Wheel #3 Spin Axis         19    -0.11128D-01  -0.15780D-01   0.72556D-01   0.27852D+00   0.87679D-02  -0.21806D+00
Cryo Cooler Pump                     8     0.15850D-01   0.25237D+00   0.17079D+00   0.10720D+00   0.20159D+00   0.39383D+00
Cryo Cooler Pump                     8     0.15850D-01   0.25237D+00   0.17079D+00   0.10720D+00   0.20159D+00   0.39383D+00
Cryo Cooler Pump                     8     0.15850D-01   0.25237D+00   0.17079D+00   0.10720D+00   0.20159D+00   0.39383D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.49855D-01  -0.11085D-01  -0.35258D-01  -0.24391D-01   0.26434D-01  -0.26240D-01
Accelerometers                       7     0.49855D-01  -0.11085D-01  -0.35258D-01  -0.24391D-01   0.26434D-01  -0.26240D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors            6     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors            6     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors            6     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors            6     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors            6     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Second Mirror                        9     0.25282D+00   0.25194D+00   0.15890D+00   0.14246D-01   0.19594D+00   0.37039D+00
Second Mirror                        9     0.25282D+00   0.25194D+00   0.15890D+00   0.14246D-01   0.19594D+00   0.37039D+00
Sensitive Instrument 2              10     0.10846D+00   0.41911D-01  -0.54791D-01  -0.41915D-01   0.24943D-01  -0.22950D-01
Sensitive Instrument 2              10     0.10846D+00   0.41911D-01  -0.54791D-01  -0.41915D-01   0.24943D-01  -0.22950D-01
Sensitive Instrument 3              11     0.79149D-01   0.25547D-01  -0.27911D-01  -0.32171D-01   0.23532D-01  -0.28195D-01
Sensitive Instrument 4              12     0.86376D-01   0.22158D-01  -0.38773D-01  -0.32348D-01   0.23026D-01  -0.27710D-01
Sensitive Instrument 5              13     0.83122D-01   0.19350D-01  -0.37295D-01  -0.32348D-01   0.23068D-01  -0.27702D-01

MODE# 84/ 84, Frequency (rad/sec), Damping (zeta), Generalized Mass=    669.00       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.14780D-01   0.19039D+00  -0.10924D-01   0.48634D-01  -0.13301D-01  -0.12320D+00
RCS Jet #2    (+X)                  22    -0.24249D-01  -0.74479D-01  -0.81676D-01   0.10903D+00  -0.65113D-01   0.36134D+00
RCS Jet #3    (+Y)                  23    -0.19980D+00   0.27855D-01  -0.97116D-02  -0.15815D-01   0.91804D-03   0.14502D+00
RCS Jet #4    (-Y)                  24     0.74037D-01   0.13193D-01   0.53743D-01   0.92305D-02  -0.10764D+00   0.10947D+00
RCS Jet #5    (-Y)                  25    -0.23716D+00   0.13946D+00   0.49981D-01   0.12271D+00   0.15370D-01   0.25231D+00
RCS Jet #6    (+Y)                  26     0.26033D+00   0.11149D+00  -0.14380D+00   0.13640D+00  -0.14956D+00   0.46337D+00
RCS Jet #7    (+X)                  27     0.27487D+00  -0.37902D+00   0.34949D+00   0.85782D+00   0.50090D+00   0.15277D+01
RCS Jet #8    (+X)                  28     0.44175D+00  -0.63066D+00   0.33822D+00   0.85778D+00   0.50092D+00   0.15280D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.62088D-01  -0.68273D-01   0.11445D+00   0.23947D+00   0.29758D+00   0.34694D+00
Reaction Wheel #2 Spin Axis         18     0.17631D-01  -0.16090D+00   0.41201D-01   0.18136D+00  -0.74941D+00  -0.11004D+01
Reaction Wheel #3 Spin Axis         19    -0.21647D+00  -0.57430D-01  -0.23716D+00  -0.83893D+00  -0.40412D+00   0.13417D+01
Cryo Cooler Pump                     8     0.35456D-01  -0.13262D+00   0.13998D+00  -0.11439D+00   0.69890D+00   0.86214D+00
Cryo Cooler Pump                     8     0.35456D-01  -0.13262D+00   0.13998D+00  -0.11439D+00   0.69890D+00   0.86214D+00
Cryo Cooler Pump                     8     0.35456D-01  -0.13262D+00   0.13998D+00  -0.11439D+00   0.69890D+00   0.86214D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.12954D-01   0.60362D-02  -0.27761D-01  -0.23006D-01  -0.15818D-01  -0.97921D-01
Accelerometers                       7    -0.12954D-01   0.60362D-02  -0.27761D-01  -0.23006D-01  -0.15818D-01  -0.97921D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors            6    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors            6    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors            6    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors            6    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors            6    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Second Mirror                        9     0.86556D+00   0.18640D-01   0.14183D+00  -0.11960D+00   0.69752D+00   0.83360D+00
Second Mirror                        9     0.86556D+00   0.18640D-01   0.14183D+00  -0.11960D+00   0.69752D+00   0.83360D+00
Sensitive Instrument 2              10     0.88428D-01   0.10655D+00  -0.74923D-01  -0.46684D-01  -0.21199D-01  -0.11819D+00
Sensitive Instrument 2              10     0.88428D-01   0.10655D+00  -0.74923D-01  -0.46684D-01  -0.21199D-01  -0.11819D+00
Sensitive Instrument 3              11    -0.27771D-01   0.39916D-01  -0.32459D-01  -0.21712D-01  -0.16373D-01  -0.10748D+00
Sensitive Instrument 4              12    -0.45193D-03   0.27233D-01  -0.35929D-01  -0.22364D-01  -0.17312D-01  -0.10768D+00
Sensitive Instrument 5              13     0.19991D-02   0.30971D-01  -0.37040D-01  -0.22364D-01  -0.17320D-01  -0.10767D+00

MODE# 85/ 85, Frequency (rad/sec), Damping (zeta), Generalized Mass=    669.99       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.18390D-01  -0.15806D+00   0.11488D-01   0.14965D-01   0.23546D-01  -0.42252D-01
RCS Jet #2    (+X)                  22     0.26637D-01   0.23201D+00  -0.35041D-01  -0.88474D-01  -0.38640D-01  -0.43637D+00
RCS Jet #3    (+Y)                  23     0.39919D-01  -0.49669D-01  -0.17514D-02   0.21457D-01  -0.25469D-01  -0.11293D+00
RCS Jet #4    (-Y)                  24    -0.51725D-01  -0.62096D-01  -0.37629D-02   0.31340D-01   0.29431D-01  -0.15114D+00
RCS Jet #5    (-Y)                  25     0.38398D+00   0.87839D-02  -0.96827D-01  -0.11437D+00  -0.11940D+00  -0.59378D+00
RCS Jet #6    (+Y)                  26    -0.22809D+00  -0.28983D-01   0.66174D-01  -0.10178D+00   0.39367D-01  -0.29527D+00
RCS Jet #7    (+X)                  27    -0.72240D-01   0.11708D+00  -0.20637D+00   0.14964D+00  -0.27132D+00  -0.19163D+00
RCS Jet #8    (+X)                  28    -0.16262D+00   0.62887D-01  -0.20026D+00   0.14964D+00  -0.27130D+00  -0.19163D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.41432D-01   0.14323D+00   0.10416D+00  -0.12354D+00   0.20228D+00  -0.19326D+00
Reaction Wheel #2 Spin Axis         18     0.56194D-01  -0.69988D-02   0.14558D+00  -0.33157D+00  -0.46898D-01   0.88960D-01
Reaction Wheel #3 Spin Axis         19    -0.11171D+00  -0.29376D-01  -0.20956D+00  -0.61903D+00  -0.37152D-01   0.51995D+00
Cryo Cooler Pump                     8    -0.18431D-01  -0.79081D-03  -0.10483D+00  -0.13566D-01  -0.20002D+00  -0.28909D+00
Cryo Cooler Pump                     8    -0.18431D-01  -0.79081D-03  -0.10483D+00  -0.13566D-01  -0.20002D+00  -0.28909D+00
Cryo Cooler Pump                     8    -0.18431D-01  -0.79081D-03  -0.10483D+00  -0.13566D-01  -0.20002D+00  -0.28909D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.38622D-01  -0.30491D-01   0.40127D-01   0.41406D-01  -0.12930D-01   0.37847D-01
Accelerometers                       7    -0.38622D-01  -0.30491D-01   0.40127D-01   0.41406D-01  -0.12930D-01   0.37847D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.18787D-01  -0.72831D-01   0.61873D-02   0.45125D-01  -0.12232D-01   0.37189D-01
Inertial Attitude Sensors            6    -0.18787D-01  -0.72831D-01   0.61873D-02   0.45125D-01  -0.12232D-01   0.37189D-01
Inertial Attitude Sensors            6    -0.18787D-01  -0.72831D-01   0.61873D-02   0.45125D-01  -0.12232D-01   0.37189D-01
Inertial Attitude Sensors            6    -0.18787D-01  -0.72831D-01   0.61873D-02   0.45125D-01  -0.12232D-01   0.37189D-01
Inertial Attitude Sensors            6    -0.18787D-01  -0.72831D-01   0.61873D-02   0.45125D-01  -0.12232D-01   0.37189D-01
Inertial Attitude Sensors            6    -0.18787D-01  -0.72831D-01   0.61873D-02   0.45125D-01  -0.12232D-01   0.37189D-01
Second Mirror                        9    -0.25318D+00   0.23311D-01  -0.11229D+00  -0.36313D-01  -0.20045D+00  -0.29012D+00
Second Mirror                        9    -0.25318D+00   0.23311D-01  -0.11229D+00  -0.36313D-01  -0.20045D+00  -0.29012D+00
Sensitive Instrument 2              10    -0.10417D+00  -0.12680D+00   0.10415D+00   0.92305D-01  -0.46712D-02   0.45317D-01
Sensitive Instrument 2              10    -0.10417D+00  -0.12680D+00   0.10415D+00   0.92305D-01  -0.46712D-02   0.45317D-01
Sensitive Instrument 3              11    -0.56288D-01  -0.93060D-01   0.34229D-01   0.58142D-01  -0.13866D-01   0.44662D-01
Sensitive Instrument 4              12    -0.67608D-01  -0.87737D-01   0.50362D-01   0.59186D-01  -0.11785D-01   0.44081D-01
Sensitive Instrument 5              13    -0.65944D-01  -0.82172D-01   0.49605D-01   0.59195D-01  -0.11813D-01   0.44056D-01

MODE# 86/ 86, Frequency (rad/sec), Damping (zeta), Generalized Mass=    676.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.12927D-01   0.32857D-02  -0.42482D-02  -0.89274D-02  -0.70415D-02   0.29686D-02
RCS Jet #2    (+X)                  22    -0.62521D-02  -0.45065D-01   0.58888D-02   0.19578D-01   0.76868D-02   0.75434D-01
RCS Jet #3    (+Y)                  23    -0.51685D-02   0.18992D-01  -0.92289D-02   0.54493D-03   0.10690D-01   0.44966D-01
RCS Jet #4    (-Y)                  24     0.45916D-02   0.21760D-01  -0.48247D-04  -0.11208D-02  -0.17237D-01   0.52615D-01
RCS Jet #5    (-Y)                  25    -0.70672D-01  -0.76402D-02   0.19473D-01   0.24778D-01   0.22658D-01   0.11068D+00
RCS Jet #6    (+Y)                  26     0.37539D-01  -0.13623D-03  -0.15853D-01   0.22987D-01  -0.73304D-02   0.50818D-01
RCS Jet #7    (+X)                  27     0.17610D-01  -0.29667D-01   0.48372D-01   0.25058D-01   0.65185D-01   0.95827D-01
RCS Jet #8    (+X)                  28     0.39324D-01  -0.35867D-01   0.46904D-01   0.25056D-01   0.65182D-01   0.95837D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.10519D-01  -0.11316D-01  -0.14339D-01   0.23245D-01  -0.28134D-01   0.55926D-01
Reaction Wheel #2 Spin Axis         18     0.52489D-02  -0.56774D-01   0.57476D-01  -0.71389D-01  -0.16265D+00  -0.15054D+00
Reaction Wheel #3 Spin Axis         19    -0.74285D-03   0.72798D-02   0.14783D-02   0.41496D-01   0.31332D-01  -0.74130D-01
Cryo Cooler Pump                     8    -0.31698D-02  -0.11699D-01  -0.49016D-02  -0.73687D-02   0.11367D-01   0.11574D-01
Cryo Cooler Pump                     8    -0.31698D-02  -0.11699D-01  -0.49016D-02  -0.73687D-02   0.11367D-01   0.11574D-01
Cryo Cooler Pump                     8    -0.31698D-02  -0.11699D-01  -0.49016D-02  -0.73687D-02   0.11367D-01   0.11574D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.74282D-02  -0.22681D-02  -0.12400D-01  -0.24842D-02   0.67014D-02  -0.53155D-02
Accelerometers                       7     0.74282D-02  -0.22681D-02  -0.12400D-01  -0.24842D-02   0.67014D-02  -0.53155D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.45342D-02   0.37763D-02  -0.40951D-02  -0.34398D-02   0.66338D-02  -0.52765D-02
Inertial Attitude Sensors            6     0.45342D-02   0.37763D-02  -0.40951D-02  -0.34398D-02   0.66338D-02  -0.52765D-02
Inertial Attitude Sensors            6     0.45342D-02   0.37763D-02  -0.40951D-02  -0.34398D-02   0.66338D-02  -0.52765D-02
Inertial Attitude Sensors            6     0.45342D-02   0.37763D-02  -0.40951D-02  -0.34398D-02   0.66338D-02  -0.52765D-02
Inertial Attitude Sensors            6     0.45342D-02   0.37763D-02  -0.40951D-02  -0.34398D-02   0.66338D-02  -0.52765D-02
Inertial Attitude Sensors            6     0.45342D-02   0.37763D-02  -0.40951D-02  -0.34398D-02   0.66338D-02  -0.52765D-02
Second Mirror                        9     0.10154D-01  -0.45585D-02  -0.52660D-02  -0.79207D-02   0.11162D-01   0.10973D-01
Second Mirror                        9     0.10154D-01  -0.45585D-02  -0.52660D-02  -0.79207D-02   0.11162D-01   0.10973D-01
Sensitive Instrument 2              10     0.20594D-01   0.39208D-02  -0.11536D-01  -0.28742D-02   0.72853D-02  -0.49201D-02
Sensitive Instrument 2              10     0.20594D-01   0.39208D-02  -0.11536D-01  -0.28742D-02   0.72853D-02  -0.49201D-02
Sensitive Instrument 3              11     0.14331D-01   0.70155D-03  -0.11171D-01  -0.27641D-02   0.59893D-02  -0.61194D-02
Sensitive Instrument 4              12     0.15908D-01  -0.28722D-04  -0.12575D-01  -0.27566D-02   0.60253D-02  -0.61183D-02
Sensitive Instrument 5              13     0.15056D-01  -0.26799D-04  -0.12188D-01  -0.27563D-02   0.60322D-02  -0.61180D-02

MODE# 87/ 87, Frequency (rad/sec), Damping (zeta), Generalized Mass=    679.93       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.11845D+00  -0.53646D-01  -0.10233D+00  -0.65765D-02  -0.12020D+00   0.16886D-01
RCS Jet #2    (+X)                  22    -0.22678D-01  -0.35702D-01   0.59367D-01  -0.22422D-01   0.79037D-01  -0.13008D-01
RCS Jet #3    (+Y)                  23     0.72340D-01   0.28821D-01  -0.51358D-01   0.13902D-01  -0.28844D-02   0.19044D-02
RCS Jet #4    (-Y)                  24    -0.50224D-02   0.53976D-01  -0.58066D-01  -0.12043D-01   0.31027D-01   0.67650D-01
RCS Jet #5    (-Y)                  25    -0.86495D-01  -0.68529D-01  -0.19687D-02  -0.16877D-01   0.65774D-01   0.19704D+00
RCS Jet #6    (+Y)                  26    -0.98348D-01  -0.16257D-01   0.37086D-01  -0.35263D-01   0.96779D-01  -0.21031D+00
RCS Jet #7    (+X)                  27    -0.11687D+00   0.13180D+00  -0.22293D+00  -0.34968D+00  -0.27950D+00  -0.54173D+00
RCS Jet #8    (+X)                  28    -0.20997D+00   0.23620D+00  -0.21664D+00  -0.34967D+00  -0.27953D+00  -0.54180D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.21946D+00   0.79866D-01   0.41030D-01  -0.26808D+00   0.18310D-01  -0.37136D+00
Reaction Wheel #2 Spin Axis         18     0.55246D-01  -0.17642D+00   0.26610D+00  -0.60137D+00  -0.15926D+00   0.28750D+00
Reaction Wheel #3 Spin Axis         19     0.18165D+00   0.16266D+00   0.25102D+00   0.88132D+00   0.29231D+00  -0.11833D+01
Cryo Cooler Pump                     8     0.65668D-02  -0.42527D-01  -0.14261D+00  -0.25096D-02  -0.24272D+00  -0.26162D+00
Cryo Cooler Pump                     8     0.65668D-02  -0.42527D-01  -0.14261D+00  -0.25096D-02  -0.24272D+00  -0.26162D+00
Cryo Cooler Pump                     8     0.65668D-02  -0.42527D-01  -0.14261D+00  -0.25096D-02  -0.24272D+00  -0.26162D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.48085D-01   0.12056D-01  -0.82126D-01  -0.14917D-02   0.43037D-01   0.21983D-01
Accelerometers                       7     0.48085D-01   0.12056D-01  -0.82126D-01  -0.14917D-02   0.43037D-01   0.21983D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors            6     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors            6     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors            6     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors            6     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors            6     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Second Mirror                        9    -0.28224D+00  -0.67270D-01  -0.14602D+00  -0.36128D-02  -0.24227D+00  -0.25145D+00
Second Mirror                        9    -0.28224D+00  -0.67270D-01  -0.14602D+00  -0.36128D-02  -0.24227D+00  -0.25145D+00
Sensitive Instrument 2              10     0.67315D-01  -0.37554D-02  -0.57086D-01   0.75494D-02   0.48318D-01   0.35778D-01
Sensitive Instrument 2              10     0.67315D-01  -0.37554D-02  -0.57086D-01   0.75494D-02   0.48318D-01   0.35778D-01
Sensitive Instrument 3              11     0.93186D-01   0.10290D-01  -0.75477D-01  -0.84754D-03   0.38922D-01   0.22862D-01
Sensitive Instrument 4              12     0.87508D-01   0.12959D-01  -0.80239D-01  -0.71644D-03   0.39430D-01   0.22631D-01
Sensitive Instrument 5              13     0.81930D-01   0.11406D-01  -0.77708D-01  -0.71975D-03   0.39464D-01   0.22630D-01

MODE# 88/ 88, Frequency (rad/sec), Damping (zeta), Generalized Mass=    687.55       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.88530D-01  -0.14984D+00  -0.37508D-01  -0.57541D-01  -0.10718D-01   0.97218D-02
RCS Jet #2    (+X)                  22    -0.16478D-01   0.63193D-01  -0.59664D-01  -0.27182D-01  -0.54774D-01   0.33866D-01
RCS Jet #3    (+Y)                  23    -0.96665D-01   0.64811D-01   0.37316D-02  -0.89285D-02  -0.70418D-01   0.14425D+00
RCS Jet #4    (-Y)                  24     0.18622D-01   0.52920D-01   0.16440D-01   0.90132D-02  -0.84415D-03   0.10680D+00
RCS Jet #5    (-Y)                  25    -0.44766D-01   0.84206D-01  -0.56200D-01  -0.41911D-01  -0.80688D-01   0.40975D-01
RCS Jet #6    (+Y)                  26    -0.46507D-02   0.89047D-01  -0.76270D-02  -0.23934D-01  -0.42133D-01  -0.50202D-02
RCS Jet #7    (+X)                  27     0.43920D-01  -0.17695D-01  -0.47724D-01   0.50009D-01  -0.22220D-01   0.90252D-01
RCS Jet #8    (+X)                  28     0.36535D-01  -0.32339D-01  -0.47229D-01   0.50008D-01  -0.22232D-01   0.90264D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.35037D-01   0.91819D-01   0.59718D-01  -0.88678D-02   0.14747D+00   0.48830D-01
Reaction Wheel #2 Spin Axis         18     0.21427D-01   0.16229D-01   0.11991D+00  -0.19474D+00  -0.47586D+00  -0.48133D+00
Reaction Wheel #3 Spin Axis         19    -0.55739D-01   0.59169D-02  -0.18694D+00  -0.43753D+00   0.20719D+00   0.82063D-01
Cryo Cooler Pump                     8    -0.32157D-01  -0.21119D+00  -0.11167D+00  -0.15540D+00   0.24154D+00   0.18896D+00
Cryo Cooler Pump                     8    -0.32157D-01  -0.21119D+00  -0.11167D+00  -0.15540D+00   0.24154D+00   0.18896D+00
Cryo Cooler Pump                     8    -0.32157D-01  -0.21119D+00  -0.11167D+00  -0.15540D+00   0.24154D+00   0.18896D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.65166D-02  -0.23510D-01   0.31785D-01   0.52949D-01   0.25784D-01  -0.54589D-01
Accelerometers                       7     0.65166D-02  -0.23510D-01   0.31785D-01   0.52949D-01   0.25784D-01  -0.54589D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.29224D-01   0.37386D-01   0.20805D-01   0.44178D-01   0.73616D-02  -0.53790D-01
Inertial Attitude Sensors            6    -0.29224D-01   0.37386D-01   0.20805D-01   0.44178D-01   0.73616D-02  -0.53790D-01
Inertial Attitude Sensors            6    -0.29224D-01   0.37386D-01   0.20805D-01   0.44178D-01   0.73616D-02  -0.53790D-01
Inertial Attitude Sensors            6    -0.29224D-01   0.37386D-01   0.20805D-01   0.44178D-01   0.73616D-02  -0.53790D-01
Inertial Attitude Sensors            6    -0.29224D-01   0.37386D-01   0.20805D-01   0.44178D-01   0.73616D-02  -0.53790D-01
Inertial Attitude Sensors            6    -0.29224D-01   0.37386D-01   0.20805D-01   0.44178D-01   0.73616D-02  -0.53790D-01
Second Mirror                        9     0.25728D+00  -0.51646D-01  -0.11785D+00  -0.16298D+00   0.24022D+00   0.17195D+00
Second Mirror                        9     0.25728D+00  -0.51646D-01  -0.11785D+00  -0.16298D+00   0.24022D+00   0.17195D+00
Sensitive Instrument 2              10     0.90243D-01  -0.54370D-01   0.13929D+00   0.97853D-01   0.37672D-01  -0.59492D-01
Sensitive Instrument 2              10     0.90243D-01  -0.54370D-01   0.13929D+00   0.97853D-01   0.37672D-01  -0.59492D-01
Sensitive Instrument 3              11     0.23427D-01  -0.81695D-01   0.37088D-01   0.69126D-01   0.15337D-01  -0.64842D-01
Sensitive Instrument 4              12     0.40110D-01  -0.89404D-01   0.52558D-01   0.70993D-01   0.18655D-01  -0.64613D-01
Sensitive Instrument 5              13     0.37475D-01  -0.75190D-01   0.53755D-01   0.71003D-01   0.18694D-01  -0.64640D-01

MODE# 89/ 89, Frequency (rad/sec), Damping (zeta), Generalized Mass=    693.45       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.65016D-01   0.12186D+00   0.57537D-01  -0.18329D-01   0.19247D-01  -0.69566D-01
RCS Jet #2    (+X)                  22     0.25647D-01   0.77644D-01   0.63720D-01  -0.52498D-01   0.54988D-01  -0.29688D+00
RCS Jet #3    (+Y)                  23     0.72367D-01  -0.17515D+00   0.72116D-01  -0.18025D-01   0.24824D-01  -0.22243D+00
RCS Jet #4    (-Y)                  24     0.19335D-02  -0.16511D+00  -0.59921D-01  -0.37212D-01   0.58273D-01  -0.19457D+00
RCS Jet #5    (-Y)                  25     0.28514D+00  -0.72932D-01  -0.60851D-02  -0.47299D-01   0.40684D-01  -0.44352D+00
RCS Jet #6    (+Y)                  26    -0.12476D+00  -0.11103D+00   0.79374D-01  -0.68456D-01   0.90617D-01  -0.12944D+00
RCS Jet #7    (+X)                  27    -0.77621D-01   0.16965D+00  -0.32072D-02  -0.51230D+00  -0.63430D-01  -0.84798D+00
RCS Jet #8    (+X)                  28    -0.98773D-01   0.32139D+00  -0.17696D-02  -0.51229D+00  -0.63400D-01  -0.84810D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.17633D-01  -0.58856D-01   0.24744D-01  -0.42241D+00   0.29959D-01  -0.77390D+00
Reaction Wheel #2 Spin Axis         18    -0.94558D-02  -0.54903D-01  -0.18676D+00   0.35369D+00   0.91870D+00   0.88490D+00
Reaction Wheel #3 Spin Axis         19    -0.82915D-02  -0.11362D+00   0.18321D+00   0.28886D+00  -0.56150D+00   0.49388D+00
Cryo Cooler Pump                     8     0.19452D-01   0.24738D+00   0.23053D+00   0.15983D+00  -0.15858D+00  -0.97832D-01
Cryo Cooler Pump                     8     0.19452D-01   0.24738D+00   0.23053D+00   0.15983D+00  -0.15858D+00  -0.97832D-01
Cryo Cooler Pump                     8     0.19452D-01   0.24738D+00   0.23053D+00   0.15983D+00  -0.15858D+00  -0.97832D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.13191D-01  -0.16073D-01  -0.47963D-01  -0.87046D-01  -0.51208D-01   0.40946D-01
Accelerometers                       7    -0.13191D-01  -0.16073D-01  -0.47963D-01  -0.87046D-01  -0.51208D-01   0.40946D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors            6     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors            6     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors            6     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors            6     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors            6     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Second Mirror                        9    -0.17213D+00   0.10321D+00   0.23847D+00   0.16961D+00  -0.15785D+00  -0.83555D-01
Second Mirror                        9    -0.17213D+00   0.10321D+00   0.23847D+00   0.16961D+00  -0.15785D+00  -0.83555D-01
Sensitive Instrument 2              10    -0.10636D+00   0.46671D-01  -0.21872D+00  -0.13891D+00  -0.68645D-01   0.43232D-01
Sensitive Instrument 2              10    -0.10636D+00   0.46671D-01  -0.21872D+00  -0.13891D+00  -0.68645D-01   0.43232D-01
Sensitive Instrument 3              11    -0.51745D-01   0.69204D-01  -0.58912D-01  -0.10358D+00  -0.38254D-01   0.55499D-01
Sensitive Instrument 4              12    -0.66110D-01   0.75849D-01  -0.80424D-01  -0.10616D+00  -0.42707D-01   0.54868D-01
Sensitive Instrument 5              13    -0.60072D-01   0.57276D-01  -0.83164D-01  -0.10617D+00  -0.42769D-01   0.54902D-01

MODE# 90/ 90, Frequency (rad/sec), Damping (zeta), Generalized Mass=    707.96       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.39315D+00   0.41388D-01   0.18241D+00   0.12337D-01   0.75712D-01   0.22144D-01
RCS Jet #2    (+X)                  22     0.34931D-01   0.84287D-01  -0.40799D-01   0.18793D-01  -0.12378D+00  -0.11622D+00
RCS Jet #3    (+Y)                  23    -0.12270D+00  -0.14477D-01  -0.32559D-01  -0.24403D-01   0.26341D-01   0.33424D-01
RCS Jet #4    (-Y)                  24    -0.84214D-01  -0.71117D-01  -0.28665D-01   0.42641D-01  -0.29852D-01  -0.11990D+00
RCS Jet #5    (-Y)                  25     0.35936D+00   0.10716D+00   0.34343D-01  -0.52292D-02  -0.12637D+00  -0.82175D+00
RCS Jet #6    (+Y)                  26     0.18120D+00  -0.68131D-01   0.67502D-02   0.42994D-01  -0.13214D+00   0.55093D+00
RCS Jet #7    (+X)                  27     0.26036D+00  -0.13354D+00   0.84398D+00   0.44447D+00   0.97354D+00   0.60456D+00
RCS Jet #8    (+X)                  28     0.58458D+00  -0.26812D+00   0.82208D+00   0.44444D+00   0.97358D+00   0.60466D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.22981D+00  -0.62659D-01  -0.79616D-01   0.38128D+00  -0.64655D-01   0.51596D+00
Reaction Wheel #2 Spin Axis         18     0.51661D-01  -0.56534D-01  -0.25213D-01   0.13106D+00  -0.81434D-01  -0.28820D+00
Reaction Wheel #3 Spin Axis         19     0.15350D+00   0.89432D-01   0.82348D-01   0.13186D+00   0.56748D-01  -0.10117D+00
Cryo Cooler Pump                     8    -0.93160D-01   0.80638D-01   0.72259D-01   0.57402D-01   0.12638D+00   0.41261D-02
Cryo Cooler Pump                     8    -0.93160D-01   0.80638D-01   0.72259D-01   0.57402D-01   0.12638D+00   0.41261D-02
Cryo Cooler Pump                     8    -0.93160D-01   0.80638D-01   0.72259D-01   0.57402D-01   0.12638D+00   0.41261D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.11192D+00  -0.79379D-02  -0.12330D-01  -0.15458D-01  -0.21218D-01  -0.35891D-02
Accelerometers                       7    -0.11192D+00  -0.79379D-02  -0.12330D-01  -0.15458D-01  -0.21218D-01  -0.35891D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.10349D+00  -0.14720D-02  -0.29543D-02  -0.26552D-01   0.10601D-02  -0.26863D-02
Inertial Attitude Sensors            6    -0.10349D+00  -0.14720D-02  -0.29543D-02  -0.26552D-01   0.10601D-02  -0.26863D-02
Inertial Attitude Sensors            6    -0.10349D+00  -0.14720D-02  -0.29543D-02  -0.26552D-01   0.10601D-02  -0.26863D-02
Inertial Attitude Sensors            6    -0.10349D+00  -0.14720D-02  -0.29543D-02  -0.26552D-01   0.10601D-02  -0.26863D-02
Inertial Attitude Sensors            6    -0.10349D+00  -0.14720D-02  -0.29543D-02  -0.26552D-01   0.10601D-02  -0.26863D-02
Inertial Attitude Sensors            6    -0.10349D+00  -0.14720D-02  -0.29543D-02  -0.26552D-01   0.10601D-02  -0.26863D-02
Second Mirror                        9     0.55417D-01   0.37459D-01   0.75152D-01   0.50675D-01   0.12314D+00  -0.46708D-02
Second Mirror                        9     0.55417D-01   0.37459D-01   0.75152D-01   0.50675D-01   0.12314D+00  -0.46708D-02
Sensitive Instrument 2              10    -0.14173D+00   0.36319D-02  -0.51130D-01  -0.19499D-01  -0.23646D-01  -0.20628D-01
Sensitive Instrument 2              10    -0.14173D+00   0.36319D-02  -0.51130D-01  -0.19499D-01  -0.23646D-01  -0.20628D-01
Sensitive Instrument 3              11    -0.13989D+00  -0.81576D-03  -0.28926D-01  -0.80994D-02  -0.83192D-02   0.36788D-03
Sensitive Instrument 4              12    -0.14018D+00  -0.63038D-03  -0.30000D-01  -0.92256D-02  -0.98155D-02  -0.87815D-03
Sensitive Instrument 5              13    -0.13881D+00  -0.18828D-02  -0.30630D-01  -0.92239D-02  -0.99160D-02  -0.87407D-03

MODE# 91/ 91, Frequency (rad/sec), Damping (zeta), Generalized Mass=    709.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.92101D-01  -0.13633D-01  -0.36971D-01  -0.24994D-02  -0.13900D-01  -0.11211D-02
RCS Jet #2    (+X)                  22    -0.74215D-02  -0.17522D-01   0.56192D-02  -0.37302D-02   0.26035D-01   0.27464D-01
RCS Jet #3    (+Y)                  23     0.23778D-01   0.70025D-02   0.53388D-02   0.46553D-02  -0.80123D-02   0.17404D-02
RCS Jet #4    (-Y)                  24     0.19927D-01   0.18381D-01   0.51345D-02  -0.83497D-02   0.48058D-02   0.31775D-01
RCS Jet #5    (-Y)                  25    -0.74792D-01  -0.19512D-01  -0.99101D-02   0.15312D-02   0.27077D-01   0.16715D+00
RCS Jet #6    (+Y)                  26    -0.33289D-01   0.15245D-01  -0.44752D-02  -0.89626D-02   0.28057D-01  -0.10481D+00
RCS Jet #7    (+X)                  27    -0.51588D-01   0.25756D-01  -0.18087D+00  -0.86510D-01  -0.20630D+00  -0.11612D+00
RCS Jet #8    (+X)                  28    -0.12029D+00   0.51987D-01  -0.17622D+00  -0.86507D-01  -0.20630D+00  -0.11613D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.51228D-01   0.16453D-01   0.20245D-01  -0.76434D-01   0.24486D-01  -0.98578D-01
Reaction Wheel #2 Spin Axis         18    -0.84070D-02   0.12055D-01   0.10719D-01  -0.38136D-01  -0.90355D-02   0.34338D-01
Reaction Wheel #3 Spin Axis         19    -0.31612D-01  -0.15538D-01  -0.24874D-01  -0.44216D-01  -0.13877D-02   0.20735D-01
Cryo Cooler Pump                     8     0.19321D-01  -0.33338D-01  -0.24914D-01  -0.22296D-01  -0.20435D-01   0.15043D-02
Cryo Cooler Pump                     8     0.19321D-01  -0.33338D-01  -0.24914D-01  -0.22296D-01  -0.20435D-01   0.15043D-02
Cryo Cooler Pump                     8     0.19321D-01  -0.33338D-01  -0.24914D-01  -0.22296D-01  -0.20435D-01   0.15043D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.23545D-01   0.19820D-02  -0.38961D-02   0.26857D-02   0.31446D-02  -0.12505D-02
Accelerometers                       7     0.23545D-01   0.19820D-02  -0.38961D-02   0.26857D-02   0.31446D-02  -0.12505D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.21357D-01   0.33381D-02  -0.57220D-02   0.30456D-02   0.11350D-03  -0.12329D-02
Inertial Attitude Sensors            6     0.21357D-01   0.33381D-02  -0.57220D-02   0.30456D-02   0.11350D-03  -0.12329D-02
Inertial Attitude Sensors            6     0.21357D-01   0.33381D-02  -0.57220D-02   0.30456D-02   0.11350D-03  -0.12329D-02
Inertial Attitude Sensors            6     0.21357D-01   0.33381D-02  -0.57220D-02   0.30456D-02   0.11350D-03  -0.12329D-02
Inertial Attitude Sensors            6     0.21357D-01   0.33381D-02  -0.57220D-02   0.30456D-02   0.11350D-03  -0.12329D-02
Inertial Attitude Sensors            6     0.21357D-01   0.33381D-02  -0.57220D-02   0.30456D-02   0.11350D-03  -0.12329D-02
Second Mirror                        9    -0.44190D-02  -0.15688D-01  -0.25916D-01  -0.20762D-01  -0.19753D-01   0.27052D-02
Second Mirror                        9    -0.44190D-02  -0.15688D-01  -0.25916D-01  -0.20762D-01  -0.19753D-01   0.27052D-02
Sensitive Instrument 2              10     0.31357D-01   0.69936D-03   0.25425D-02   0.45472D-02   0.38365D-02   0.20497D-02
Sensitive Instrument 2              10     0.31357D-01   0.69936D-03   0.25425D-02   0.45472D-02   0.38365D-02   0.20497D-02
Sensitive Instrument 3              11     0.28441D-01   0.29279D-03  -0.10653D-02   0.20040D-02   0.33440D-03  -0.22332D-02
Sensitive Instrument 4              12     0.29057D-01   0.43430D-05  -0.59389D-03   0.22073D-02   0.66144D-03  -0.20785D-02
Sensitive Instrument 5              13     0.28968D-01   0.45091D-03  -0.55121D-03   0.22069D-02   0.68084D-03  -0.20796D-02

MODE# 92/ 92, Frequency (rad/sec), Damping (zeta), Generalized Mass=    712.52       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.17656D-01  -0.12540D-01   0.23875D-01  -0.67972D-03   0.12846D-01   0.53904D-02
RCS Jet #2    (+X)                  22     0.30358D-02   0.10316D-01  -0.43965D-02  -0.15437D-02  -0.77917D-02  -0.14960D-01
RCS Jet #3    (+Y)                  23    -0.12831D-01   0.28881D-02  -0.43953D-02  -0.46309D-02  -0.39253D-02   0.17665D-01
RCS Jet #4    (-Y)                  24    -0.35220D-02  -0.29520D-02  -0.99180D-02   0.31288D-02  -0.81674D-03  -0.59417D-03
RCS Jet #5    (-Y)                  25     0.42770D-01   0.12687D-01  -0.20397D-02  -0.36192D-02  -0.89272D-02  -0.10017D+00
RCS Jet #6    (+Y)                  26     0.19830D-01  -0.82212D-02   0.99087D-03  -0.48217D-03  -0.57902D-02   0.64450D-01
RCS Jet #7    (+X)                  27     0.21806D-01  -0.38647D-02   0.73272D-01   0.68928D-02   0.84894D-01   0.10095D-01
RCS Jet #8    (+X)                  28     0.50080D-01  -0.59356D-02   0.71365D-01   0.68926D-02   0.84907D-01   0.10097D-01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.14294D-01  -0.85284D-04  -0.43266D-02   0.25213D-01   0.31991D-02   0.39906D-01
Reaction Wheel #2 Spin Axis         18     0.53836D-02  -0.52157D-02   0.55254D-02  -0.80676D-02  -0.33689D-01  -0.46256D-01
Reaction Wheel #3 Spin Axis         19     0.16054D-01   0.14981D-01   0.37999D-02   0.11326D-01   0.19877D-01  -0.28772D-01
Cryo Cooler Pump                     8    -0.94455D-02  -0.18455D-01  -0.88113D-02  -0.99546D-02   0.15833D-01  -0.10526D-02
Cryo Cooler Pump                     8    -0.94455D-02  -0.18455D-01  -0.88113D-02  -0.99546D-02   0.15833D-01  -0.10526D-02
Cryo Cooler Pump                     8    -0.94455D-02  -0.18455D-01  -0.88113D-02  -0.99546D-02   0.15833D-01  -0.10526D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.83852D-02  -0.54900D-03  -0.19794D-01  -0.55223D-02  -0.28813D-02  -0.33689D-02
Accelerometers                       7    -0.83852D-02  -0.54900D-03  -0.19794D-01  -0.55223D-02  -0.28813D-02  -0.33689D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.75371D-02   0.43540D-02  -0.14527D-01  -0.10707D-01   0.35971D-02  -0.28418D-02
Inertial Attitude Sensors            6    -0.75371D-02   0.43540D-02  -0.14527D-01  -0.10707D-01   0.35971D-02  -0.28418D-02
Inertial Attitude Sensors            6    -0.75371D-02   0.43540D-02  -0.14527D-01  -0.10707D-01   0.35971D-02  -0.28418D-02
Inertial Attitude Sensors            6    -0.75371D-02   0.43540D-02  -0.14527D-01  -0.10707D-01   0.35971D-02  -0.28418D-02
Inertial Attitude Sensors            6    -0.75371D-02   0.43540D-02  -0.14527D-01  -0.10707D-01   0.35971D-02  -0.28418D-02
Inertial Attitude Sensors            6    -0.75371D-02   0.43540D-02  -0.14527D-01  -0.10707D-01   0.35971D-02  -0.28418D-02
Second Mirror                        9     0.93978D-02  -0.10595D-01  -0.91507D-02  -0.10150D-01   0.15493D-01  -0.25153D-02
Second Mirror                        9     0.93978D-02  -0.10595D-01  -0.91507D-02  -0.10150D-01   0.15493D-01  -0.25153D-02
Sensitive Instrument 2              10    -0.73836D-02   0.55290D-02  -0.30463D-01  -0.54292D-02  -0.30054D-02  -0.50171D-02
Sensitive Instrument 2              10    -0.73836D-02   0.55290D-02  -0.30463D-01  -0.54292D-02  -0.30054D-02  -0.50171D-02
Sensitive Instrument 3              11    -0.10900D-01   0.28759D-02  -0.22479D-01  -0.36703D-02  -0.17063D-02  -0.30202D-02
Sensitive Instrument 4              12    -0.10138D-01   0.25428D-02  -0.23193D-01  -0.39179D-02  -0.19428D-02  -0.33707D-02
Sensitive Instrument 5              13    -0.98648D-02   0.22037D-02  -0.23318D-01  -0.39179D-02  -0.19552D-02  -0.33696D-02

MODE# 93/ 93, Frequency (rad/sec), Damping (zeta), Generalized Mass=    715.40       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.32546D+00   0.16261D-01   0.13996D+00  -0.74599D-02   0.55678D-01  -0.40409D-02
RCS Jet #2    (+X)                  22     0.30229D-01   0.47228D-01  -0.18680D-01   0.27894D-01  -0.83376D-01  -0.75730D-01
RCS Jet #3    (+Y)                  23    -0.83518D-01   0.96099D-02  -0.46124D-01  -0.16837D-01   0.44888D-01   0.64770D-01
RCS Jet #4    (-Y)                  24    -0.69693D-01  -0.34373D-01  -0.40135D-01   0.35832D-01  -0.22613D-01  -0.58877D-01
RCS Jet #5    (-Y)                  25     0.28507D+00   0.76987D-01   0.44316D-01   0.12912D-01  -0.76439D-01  -0.65993D+00
RCS Jet #6    (+Y)                  26     0.16925D+00  -0.69245D-01  -0.14664D-03   0.48287D-01  -0.95939D-01   0.48796D+00
RCS Jet #7    (+X)                  27     0.22182D+00  -0.12149D+00   0.79675D+00   0.41675D+00   0.93554D+00   0.57493D+00
RCS Jet #8    (+X)                  28     0.53338D+00  -0.24750D+00   0.77570D+00   0.41674D+00   0.93556D+00   0.57503D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.18040D+00  -0.40719D-01  -0.10279D+00   0.32106D+00  -0.14113D+00   0.45902D+00
Reaction Wheel #2 Spin Axis         18     0.41276D-01  -0.61743D-01   0.25692D-01  -0.16649D-01  -0.12536D+00  -0.21344D+00
Reaction Wheel #3 Spin Axis         19     0.10870D+00   0.87753D-01   0.54892D-01   0.13907D+00   0.11733D+00  -0.20417D+00
Cryo Cooler Pump                     8    -0.65965D-01   0.23615D-01   0.19253D-01   0.23484D-01   0.56930D-01  -0.37253D-01
Cryo Cooler Pump                     8    -0.65965D-01   0.23615D-01   0.19253D-01   0.23484D-01   0.56930D-01  -0.37253D-01
Cryo Cooler Pump                     8    -0.65965D-01   0.23615D-01   0.19253D-01   0.23484D-01   0.56930D-01  -0.37253D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.79625D-01  -0.54592D-02  -0.43447D-01  -0.16333D-01  -0.82925D-02   0.19376D-02
Accelerometers                       7    -0.79625D-01  -0.54592D-02  -0.43447D-01  -0.16333D-01  -0.82925D-02   0.19376D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.68150D-01  -0.46799D-02  -0.20679D-01  -0.28854D-01   0.15526D-01   0.26801D-02
Inertial Attitude Sensors            6    -0.68150D-01  -0.46799D-02  -0.20679D-01  -0.28854D-01   0.15526D-01   0.26801D-02
Inertial Attitude Sensors            6    -0.68150D-01  -0.46799D-02  -0.20679D-01  -0.28854D-01   0.15526D-01   0.26801D-02
Inertial Attitude Sensors            6    -0.68150D-01  -0.46799D-02  -0.20679D-01  -0.28854D-01   0.15526D-01   0.26801D-02
Inertial Attitude Sensors            6    -0.68150D-01  -0.46799D-02  -0.20679D-01  -0.28854D-01   0.15526D-01   0.26801D-02
Inertial Attitude Sensors            6    -0.68150D-01  -0.46799D-02  -0.20679D-01  -0.28854D-01   0.15526D-01   0.26801D-02
Second Mirror                        9     0.47906D-03   0.22272D-02   0.20320D-01   0.20155D-01   0.54650D-01  -0.42254D-01
Second Mirror                        9     0.47906D-03   0.22272D-02   0.20320D-01   0.20155D-01   0.54650D-01  -0.42254D-01
Sensitive Instrument 2              10    -0.99667D-01   0.26079D-02  -0.74986D-01  -0.16264D-01  -0.85670D-02  -0.83867D-02
Sensitive Instrument 2              10    -0.99667D-01   0.26079D-02  -0.74986D-01  -0.16264D-01  -0.85670D-02  -0.83867D-02
Sensitive Instrument 3              11    -0.92246D-01   0.21422D-02  -0.56534D-01  -0.90943D-02   0.17298D-02   0.58274D-02
Sensitive Instrument 4              12    -0.93850D-01   0.29508D-02  -0.59027D-01  -0.10112D-01   0.54023D-03   0.45242D-02
Sensitive Instrument 5              13    -0.93942D-01   0.12267D-02  -0.58993D-01  -0.10111D-01   0.46184D-03   0.45274D-02

MODE# 94/ 94, Frequency (rad/sec), Damping (zeta), Generalized Mass=    729.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.26162D-01   0.48044D+00   0.10319D-01   0.14416D+00   0.12499D-01   0.50182D-01
RCS Jet #2    (+X)                  22     0.20759D-01  -0.33091D-01   0.84723D-01   0.79680D-01   0.14716D+00  -0.16930D+00
RCS Jet #3    (+Y)                  23     0.93455D-01  -0.28546D+00   0.13171D-01   0.36481D-01   0.65848D-01  -0.30636D+00
RCS Jet #4    (-Y)                  24     0.96631D-01  -0.25043D+00  -0.77910D-02  -0.18467D-01   0.59899D-01  -0.21628D+00
RCS Jet #5    (-Y)                  25     0.12722D+00  -0.14172D+00   0.78305D-01   0.12019D+00   0.20378D+00  -0.11942D+00
RCS Jet #6    (+Y)                  26    -0.95276D-01  -0.13411D+00  -0.51876D-01   0.58885D-01   0.13756D+00  -0.15376D+00
RCS Jet #7    (+X)                  27    -0.10749D+00  -0.66238D-01  -0.20514D+00   0.80884D+00  -0.25874D+00   0.79090D+00
RCS Jet #8    (+X)                  28    -0.19366D+00  -0.31811D+00  -0.19930D+00   0.80881D+00  -0.25868D+00   0.79105D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.44048D-01  -0.78217D-01  -0.16594D-01   0.11303D+00  -0.11640D+00  -0.34904D-01
Reaction Wheel #2 Spin Axis         18    -0.38055D-01  -0.10421D+00  -0.10417D+00   0.21180D+00   0.53237D+00   0.51970D+00
Reaction Wheel #3 Spin Axis         19    -0.48141D-01  -0.13303D+00   0.11141D+00   0.25849D+00  -0.41036D+00   0.29218D+00
Cryo Cooler Pump                     8     0.22055D-01   0.85123D+00   0.55782D+00   0.57832D+00  -0.80916D-01   0.12746D+00
Cryo Cooler Pump                     8     0.22055D-01   0.85123D+00   0.55782D+00   0.57832D+00  -0.80916D-01   0.12746D+00
Cryo Cooler Pump                     8     0.22055D-01   0.85123D+00   0.55782D+00   0.57832D+00  -0.80916D-01   0.12746D+00

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.27051D-01  -0.41755D-01  -0.10841D+00  -0.16174D+00  -0.10771D+00   0.31337D-01
Accelerometers                       7     0.27051D-01  -0.41755D-01  -0.10841D+00  -0.16174D+00  -0.10771D+00   0.31337D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors            6     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors            6     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors            6     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors            6     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors            6     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Second Mirror                        9    -0.84202D-01   0.37462D+00   0.58086D+00   0.55104D+00  -0.82793D-01   0.14618D+00
Second Mirror                        9    -0.84202D-01   0.37462D+00   0.58086D+00   0.55104D+00  -0.82793D-01   0.14618D+00
Sensitive Instrument 2              10    -0.10326D+00   0.10261D+00  -0.44129D+00  -0.25775D+00  -0.14594D+00   0.39481D-01
Sensitive Instrument 2              10    -0.10326D+00   0.10261D+00  -0.44129D+00  -0.25775D+00  -0.14594D+00   0.39481D-01
Sensitive Instrument 3              11    -0.51081D-01   0.11758D+00  -0.13173D+00  -0.18754D+00  -0.91387D-01   0.60026D-01
Sensitive Instrument 4              12    -0.66730D-01   0.12483D+00  -0.16799D+00  -0.19258D+00  -0.99854D-01   0.58618D-01
Sensitive Instrument 5              13    -0.52603D-01   0.93759D-01  -0.17440D+00  -0.19258D+00  -0.99946D-01   0.58685D-01

MODE# 95/ 95, Frequency (rad/sec), Damping (zeta), Generalized Mass=    740.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.35959D-01   0.28256D+00  -0.10725D-01   0.41546D-01   0.57240D-02   0.15120D-01
RCS Jet #2    (+X)                  22     0.89610D-03  -0.29061D-01   0.27685D-01   0.80617D-01   0.77184D-01  -0.28494D-01
RCS Jet #3    (+Y)                  23     0.46756D-01  -0.10690D+00  -0.23578D-01   0.40200D-01   0.75886D-01  -0.11727D+00
RCS Jet #4    (-Y)                  24     0.46677D-01  -0.85016D-01   0.27199D-01   0.10546D-01  -0.28846D-01  -0.51748D-01
RCS Jet #5    (-Y)                  25    -0.57787D-02  -0.61323D-01   0.57778D-01   0.10965D+00   0.12716D+00   0.59734D-01
RCS Jet #6    (+Y)                  26    -0.30158D-01  -0.45443D-01  -0.76508D-01   0.75504D-01   0.52528D-01  -0.53203D-01
RCS Jet #7    (+X)                  27    -0.32138D-01  -0.12351D+00  -0.12644D+00   0.96364D+00  -0.13267D+00   0.10840D+01
RCS Jet #8    (+X)                  28    -0.76304D-01  -0.42040D+00  -0.12345D+00   0.96360D+00  -0.13264D+00   0.10842D+01

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.38234D-01   0.54279D-02  -0.12327D-01   0.15698D+00  -0.54276D-01   0.16211D+00
Reaction Wheel #2 Spin Axis         18     0.23872D-02  -0.32136D-01   0.14296D-01  -0.73282D-01   0.71947D-01   0.14665D+00
Reaction Wheel #3 Spin Axis         19    -0.41638D-01  -0.34842D-01  -0.32082D-01  -0.92395D-01  -0.95136D-01   0.15960D+00
Cryo Cooler Pump                     8     0.27854D-01   0.27903D+00   0.18476D+00   0.18584D+00  -0.40835D-01   0.44672D-01
Cryo Cooler Pump                     8     0.27854D-01   0.27903D+00   0.18476D+00   0.18584D+00  -0.40835D-01   0.44672D-01
Cryo Cooler Pump                     8     0.27854D-01   0.27903D+00   0.18476D+00   0.18584D+00  -0.40835D-01   0.44672D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.54855D-02  -0.25231D-01  -0.31773D-01  -0.57026D-01  -0.61675D-01   0.15947D-01
Accelerometers                       7     0.54855D-02  -0.25231D-01  -0.31773D-01  -0.57026D-01  -0.61675D-01   0.15947D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors            6     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors            6     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors            6     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors            6     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors            6     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Second Mirror                        9    -0.22816D-01   0.13193D+00   0.19216D+00   0.17636D+00  -0.40523D-01   0.51331D-01
Second Mirror                        9    -0.22816D-01   0.13193D+00   0.19216D+00   0.17636D+00  -0.40523D-01   0.51331D-01
Sensitive Instrument 2              10    -0.69981D-01   0.84027D-02  -0.16241D+00  -0.79921D-01  -0.75637D-01   0.20849D-01
Sensitive Instrument 2              10    -0.69981D-01   0.84027D-02  -0.16241D+00  -0.79921D-01  -0.75637D-01   0.20849D-01
Sensitive Instrument 3              11    -0.43498D-01   0.20726D-01  -0.45681D-01  -0.61583D-01  -0.55313D-01   0.30511D-01
Sensitive Instrument 4              12    -0.51402D-01   0.24421D-01  -0.54644D-01  -0.63424D-01  -0.58200D-01   0.29567D-01
Sensitive Instrument 5              13    -0.43168D-01   0.13531D-01  -0.58378D-01  -0.63422D-01  -0.58252D-01   0.29587D-01

MODE# 96/ 96, Frequency (rad/sec), Damping (zeta), Generalized Mass=    744.03       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.16418D+00   0.16913D-01   0.92198D-02  -0.45490D-02  -0.17911D-01  -0.11605D-01
RCS Jet #2    (+X)                  22     0.73542D-02   0.17528D-02   0.10280D-01   0.75767D-02  -0.37148D-01  -0.13303D-01
RCS Jet #3    (+Y)                  23    -0.14178D-01   0.13863D-01  -0.26644D-01  -0.84562D-03   0.33008D-01   0.35689D-02
RCS Jet #4    (-Y)                  24    -0.50408D-01  -0.54387D-03  -0.14046D-01   0.13277D-01   0.25434D-03  -0.39649D-01
RCS Jet #5    (-Y)                  25     0.46135D-01   0.51544D-02   0.32855D-01  -0.26323D-02  -0.42881D-01  -0.99096D-01
RCS Jet #6    (+Y)                  26     0.25617D-01  -0.16846D-01   0.21209D-01   0.18731D-01  -0.46502D-01   0.68477D-01
RCS Jet #7    (+X)                  27     0.54469D-01  -0.24568D-01   0.32165D+00   0.78496D-01   0.37104D+00   0.11302D+00
RCS Jet #8    (+X)                  28     0.17801D+00  -0.48197D-01   0.31329D+00   0.78493D-01   0.37099D+00   0.11304D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.51503D-01  -0.12361D-01  -0.69956D-01   0.75415D-01  -0.16228D+00   0.99326D-01
Reaction Wheel #2 Spin Axis         18    -0.10654D-01  -0.15622D-01   0.97978D-02  -0.43276D-01   0.21216D-01   0.53033D-01
Reaction Wheel #3 Spin Axis         19     0.47312D-02   0.22641D-01   0.37884D-01   0.13078D+00   0.41994D-01  -0.13702D+00
Cryo Cooler Pump                     8    -0.14541D-01   0.11646D+00   0.25464D-01   0.85096D-01  -0.35897D-01  -0.29524D-01
Cryo Cooler Pump                     8    -0.14541D-01   0.11646D+00   0.25464D-01   0.85096D-01  -0.35897D-01  -0.29524D-01
Cryo Cooler Pump                     8    -0.14541D-01   0.11646D+00   0.25464D-01   0.85096D-01  -0.35897D-01  -0.29524D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.13756D-01   0.25656D-02   0.20922D-01   0.16106D-01   0.38160D-01   0.15802D-01
Accelerometers                       7    -0.13756D-01   0.25656D-02   0.20922D-01   0.16106D-01   0.38160D-01   0.15802D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.90434D-02  -0.17581D-01   0.47519D-01   0.25609D-01   0.27757D-01   0.13786D-01
Inertial Attitude Sensors            6    -0.90434D-02  -0.17581D-01   0.47519D-01   0.25609D-01   0.27757D-01   0.13786D-01
Inertial Attitude Sensors            6    -0.90434D-02  -0.17581D-01   0.47519D-01   0.25609D-01   0.27757D-01   0.13786D-01
Inertial Attitude Sensors            6    -0.90434D-02  -0.17581D-01   0.47519D-01   0.25609D-01   0.27757D-01   0.13786D-01
Inertial Attitude Sensors            6    -0.90434D-02  -0.17581D-01   0.47519D-01   0.25609D-01   0.27757D-01   0.13786D-01
Inertial Attitude Sensors            6    -0.90434D-02  -0.17581D-01   0.47519D-01   0.25609D-01   0.27757D-01   0.13786D-01
Second Mirror                        9    -0.59475D-01   0.39227D-01   0.27945D-01   0.79519D-01  -0.36767D-01  -0.25752D-01
Second Mirror                        9    -0.59475D-01   0.39227D-01   0.27945D-01   0.79519D-01  -0.36767D-01  -0.25752D-01
Sensitive Instrument 2              10    -0.27245D-02  -0.19172D-01   0.72705D-01   0.21254D-01   0.43106D-01   0.19428D-01
Sensitive Instrument 2              10    -0.27245D-02  -0.19172D-01   0.72705D-01   0.21254D-01   0.43106D-01   0.19428D-01
Sensitive Instrument 3              11     0.17824D-01  -0.81041D-02   0.28005D-01   0.14456D-01   0.38599D-01   0.15250D-01
Sensitive Instrument 4              12     0.13951D-01  -0.63443D-02   0.27066D-01   0.15060D-01   0.39274D-01   0.15889D-01
Sensitive Instrument 5              13     0.83907D-02  -0.52284D-02   0.29585D-01   0.15060D-01   0.39290D-01   0.15884D-01

MODE# 97/ 97, Frequency (rad/sec), Damping (zeta), Generalized Mass=    744.87       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.15796D+00  -0.12586D+00  -0.13579D-01  -0.33553D-01   0.14868D-01  -0.36572D-01
RCS Jet #2    (+X)                  22    -0.18076D-01   0.13439D-01  -0.35733D-01  -0.29360D-01   0.40963D-02   0.82685D-01
RCS Jet #3    (+Y)                  23    -0.14848D-02   0.74539D-01   0.16272D-01  -0.79710D-02  -0.31370D-01   0.26987D-01
RCS Jet #4    (-Y)                  24     0.17482D-01   0.83710D-01   0.19374D-01  -0.10258D-01  -0.31246D-01   0.71159D-01
RCS Jet #5    (-Y)                  25    -0.97622D-01   0.53945D-01  -0.58519D-01  -0.26993D-01   0.18049D-02   0.14245D+00
RCS Jet #6    (+Y)                  26     0.16259D-01   0.70740D-01  -0.13791D-01  -0.35620D-01   0.12800D-01   0.10620D-01
RCS Jet #7    (+X)                  27    -0.18455D-01   0.29705D-01  -0.26228D+00  -0.30829D+00  -0.28859D+00  -0.30619D+00
RCS Jet #8    (+X)                  28    -0.11454D+00   0.12560D+00  -0.25578D+00  -0.30829D+00  -0.28854D+00  -0.30625D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.43364D-01   0.87257D-02   0.72511D-01  -0.12637D+00   0.20156D+00  -0.13224D+00
Reaction Wheel #2 Spin Axis         18     0.19348D-01   0.32592D-01  -0.19929D-01   0.66650D-01  -0.63810D-01  -0.11824D+00
Reaction Wheel #3 Spin Axis         19     0.15166D-01   0.21960D-02  -0.40439D-01  -0.14075D+00  -0.16981D-01   0.11881D+00
Cryo Cooler Pump                     8     0.43933D-01  -0.60458D+00  -0.29382D+00  -0.42304D+00   0.33779D-01  -0.44256D-01
Cryo Cooler Pump                     8     0.43933D-01  -0.60458D+00  -0.29382D+00  -0.42304D+00   0.33779D-01  -0.44256D-01
Cryo Cooler Pump                     8     0.43933D-01  -0.60458D+00  -0.29382D+00  -0.42304D+00   0.33779D-01  -0.44256D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.85733D-02   0.36979D-01   0.18822D-01   0.35300D-01  -0.22766D-01  -0.18188D-01
Accelerometers                       7    -0.85733D-02   0.36979D-01   0.18822D-01   0.35300D-01  -0.22766D-01  -0.18188D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.17310D-01   0.60252D-01  -0.25189D-01   0.27721D-01  -0.22822D-01  -0.15973D-01
Inertial Attitude Sensors            6    -0.17310D-01   0.60252D-01  -0.25189D-01   0.27721D-01  -0.22822D-01  -0.15973D-01
Inertial Attitude Sensors            6    -0.17310D-01   0.60252D-01  -0.25189D-01   0.27721D-01  -0.22822D-01  -0.15973D-01
Inertial Attitude Sensors            6    -0.17310D-01   0.60252D-01  -0.25189D-01   0.27721D-01  -0.22822D-01  -0.15973D-01
Inertial Attitude Sensors            6    -0.17310D-01   0.60252D-01  -0.25189D-01   0.27721D-01  -0.22822D-01  -0.15973D-01
Inertial Attitude Sensors            6    -0.17310D-01   0.60252D-01  -0.25189D-01   0.27721D-01  -0.22822D-01  -0.15973D-01
Second Mirror                        9     0.93215D-01  -0.25273D+00  -0.30892D+00  -0.39437D+00   0.37414D-01  -0.55092D-01
Second Mirror                        9     0.93215D-01  -0.25273D+00  -0.30892D+00  -0.39437D+00   0.37414D-01  -0.55092D-01
Sensitive Instrument 2              10    -0.22560D-02   0.13786D-01   0.54447D-01   0.49312D-01  -0.18103D-01  -0.29434D-01
Sensitive Instrument 2              10    -0.22560D-02   0.13786D-01   0.54447D-01   0.49312D-01  -0.18103D-01  -0.29434D-01
