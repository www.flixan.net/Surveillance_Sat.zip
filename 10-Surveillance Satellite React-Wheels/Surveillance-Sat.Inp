Sensitive Instrument 3              11    -0.33077D-01  -0.24669D-02   0.15101D-01   0.42880D-01  -0.24920D-01  -0.27397D-01
Sensitive Instrument 4              12    -0.26059D-01  -0.56807D-02   0.28881D-01   0.43465D-01  -0.23537D-01  -0.27780D-01
Sensitive Instrument 5              13    -0.22727D-01   0.22646D-02   0.27370D-01   0.43463D-01  -0.23548D-01  -0.27792D-01

MODE# 98/ 98, Frequency (rad/sec), Damping (zeta), Generalized Mass=    750.31       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.16203D+00  -0.95093D-01   0.20883D-01  -0.70794D-02   0.12170D-01   0.28775D-01
RCS Jet #2    (+X)                  22     0.27568D-01  -0.70971D-01   0.28254D-01  -0.21888D-01  -0.21812D-01  -0.46332D-02
RCS Jet #3    (+Y)                  23     0.73412D-01   0.67647D-01   0.48537D-01  -0.15235D-01  -0.72024D-01   0.17026D+00
RCS Jet #4    (-Y)                  24    -0.13486D-02   0.61454D-01   0.11732D-02  -0.24126D-02  -0.85285D-02   0.98384D-01
RCS Jet #5    (-Y)                  25    -0.47297D-01  -0.99472D-01   0.17651D-01  -0.33437D-01  -0.50354D-01   0.21808D+00
RCS Jet #6    (+Y)                  26    -0.51980D-01  -0.44346D-01   0.56385D-01  -0.18158D-01  -0.18233D-01  -0.22814D+00
RCS Jet #7    (+X)                  27    -0.12127D+00   0.10653D+00  -0.29299D+00  -0.54517D+00  -0.42348D+00  -0.68420D+00
RCS Jet #8    (+X)                  28    -0.26234D+00   0.27290D+00  -0.28347D+00  -0.54515D+00  -0.42349D+00  -0.68432D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.32642D-02   0.48675D-01   0.66558D-01  -0.90161D-01   0.92788D-01  -0.35411D-01
Reaction Wheel #2 Spin Axis         18    -0.62314D-02   0.86412D-01   0.72111D-01  -0.11334D+00  -0.24392D+00  -0.23652D+00
Reaction Wheel #3 Spin Axis         19    -0.23826D-01   0.27002D-01  -0.58528D-01  -0.21880D+00   0.19930D+00  -0.53288D-01
Cryo Cooler Pump                     8     0.61409D-02   0.53512D+00   0.17722D+00   0.39715D+00  -0.13148D+00   0.14723D-01
Cryo Cooler Pump                     8     0.61409D-02   0.53512D+00   0.17722D+00   0.39715D+00  -0.13148D+00   0.14723D-01
Cryo Cooler Pump                     8     0.61409D-02   0.53512D+00   0.17722D+00   0.39715D+00  -0.13148D+00   0.14723D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.83807D-01  -0.95809D-02  -0.75607D-01  -0.65082D-02   0.96371D-01   0.21006D-01
Accelerometers                       7     0.83807D-01  -0.95809D-02  -0.75607D-01  -0.65082D-02   0.96371D-01   0.21006D-01

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.93530D-01  -0.36750D-01   0.29039D-01  -0.10011D-01   0.97290D-01   0.17002D-01
Inertial Attitude Sensors            6     0.93530D-01  -0.36750D-01   0.29039D-01  -0.10011D-01   0.97290D-01   0.17002D-01
Inertial Attitude Sensors            6     0.93530D-01  -0.36750D-01   0.29039D-01  -0.10011D-01   0.97290D-01   0.17002D-01
Inertial Attitude Sensors            6     0.93530D-01  -0.36750D-01   0.29039D-01  -0.10011D-01   0.97290D-01   0.17002D-01
Inertial Attitude Sensors            6     0.93530D-01  -0.36750D-01   0.29039D-01  -0.10011D-01   0.97290D-01   0.17002D-01
Inertial Attitude Sensors            6     0.93530D-01  -0.36750D-01   0.29039D-01  -0.10011D-01   0.97290D-01   0.17002D-01
Second Mirror                        9    -0.15956D+00   0.18155D+00   0.18990D+00   0.37002D+00  -0.13380D+00   0.32738D-01
Second Mirror                        9    -0.15956D+00   0.18155D+00   0.18990D+00   0.37002D+00  -0.13380D+00   0.32738D-01
Sensitive Instrument 2              10     0.15831D+00   0.10316D-01  -0.19997D-01  -0.10943D-01   0.10407D+00   0.47381D-01
Sensitive Instrument 2              10     0.15831D+00   0.10316D-01  -0.19997D-01  -0.10943D-01   0.10407D+00   0.47381D-01
Sensitive Instrument 3              11     0.18314D+00   0.24205D-01  -0.50230D-01  -0.17480D-01   0.87232D-01   0.19128D-01
Sensitive Instrument 4              12     0.17850D+00   0.26300D-01  -0.64864D-01  -0.16812D-01   0.87948D-01   0.20350D-01
Sensitive Instrument 5              13     0.16606D+00   0.22612D-01  -0.59219D-01  -0.16817D-01   0.88064D-01   0.20354D-01

MODE# 99/ 99, Frequency (rad/sec), Damping (zeta), Generalized Mass=    753.43       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21    -0.23726D+00   0.81930D-01  -0.12361D-01   0.12210D-01  -0.29347D-01  -0.25700D-02
RCS Jet #2    (+X)                  22    -0.10042D-01   0.40891D-01  -0.24756D-02   0.18623D-01  -0.12463D-01  -0.31838D-01
RCS Jet #3    (+Y)                  23    -0.60668D-01  -0.58079D-01  -0.48575D-01   0.83342D-02   0.61678D-01  -0.98836D-01
RCS Jet #4    (-Y)                  24    -0.33684D-01  -0.67720D-01  -0.20268D-01   0.96008D-02   0.27667D-01  -0.10345D+00
RCS Jet #5    (-Y)                  25     0.77081D-01   0.45229D-01   0.18271D-01   0.16482D-01  -0.38003D-02  -0.21791D+00
RCS Jet #6    (+Y)                  26     0.29759D-01  -0.12057D-02  -0.11694D-01   0.24210D-01  -0.18980D-01   0.15074D+00
RCS Jet #7    (+X)                  27     0.10579D+00  -0.69932D-01   0.43304D+00   0.37792D+00   0.54817D+00   0.45674D+00
RCS Jet #8    (+X)                  28     0.28835D+00  -0.18566D+00   0.42069D+00   0.37790D+00   0.54814D+00   0.45683D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17     0.28727D-01  -0.36577D-01  -0.10365D+00   0.11196D+00  -0.22085D+00   0.83320D-01
Reaction Wheel #2 Spin Axis         18    -0.14346D-01  -0.70247D-01  -0.32092D-01   0.17682D-01   0.17771D+00   0.21856D+00
Reaction Wheel #3 Spin Axis         19     0.51751D-02  -0.82667D-02   0.70029D-01   0.27113D+00  -0.91655D-01  -0.10160D+00
Cryo Cooler Pump                     8    -0.38667D-01  -0.28785D-01   0.12651D-01  -0.31202D-01   0.65147D-01  -0.14282D-02
Cryo Cooler Pump                     8    -0.38667D-01  -0.28785D-01   0.12651D-01  -0.31202D-01   0.65147D-01  -0.14282D-02
Cryo Cooler Pump                     8    -0.38667D-01  -0.28785D-01   0.12651D-01  -0.31202D-01   0.65147D-01  -0.14282D-02

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7    -0.52856D-01  -0.10450D-01   0.56362D-01   0.53623D-02  -0.22322D-01  -0.21650D-02
Accelerometers                       7    -0.52856D-01  -0.10450D-01   0.56362D-01   0.53623D-02  -0.22322D-01  -0.21650D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6    -0.57452D-01  -0.86005D-02   0.24721D-01   0.16680D-01  -0.33598D-01  -0.18077D-02
Inertial Attitude Sensors            6    -0.57452D-01  -0.86005D-02   0.24721D-01   0.16680D-01  -0.33598D-01  -0.18077D-02
Inertial Attitude Sensors            6    -0.57452D-01  -0.86005D-02   0.24721D-01   0.16680D-01  -0.33598D-01  -0.18077D-02
Inertial Attitude Sensors            6    -0.57452D-01  -0.86005D-02   0.24721D-01   0.16680D-01  -0.33598D-01  -0.18077D-02
Inertial Attitude Sensors            6    -0.57452D-01  -0.86005D-02   0.24721D-01   0.16680D-01  -0.33598D-01  -0.18077D-02
Inertial Attitude Sensors            6    -0.57452D-01  -0.86005D-02   0.24721D-01   0.16680D-01  -0.33598D-01  -0.18077D-02
Second Mirror                        9     0.39507D-01   0.95822D-02   0.12062D-01  -0.30456D-01   0.64252D-01  -0.74209D-02
Second Mirror                        9     0.39507D-01   0.95822D-02   0.12062D-01  -0.30456D-01   0.64252D-01  -0.74209D-02
Sensitive Instrument 2              10    -0.83179D-01  -0.30810D-01   0.53532D-01   0.11672D-01  -0.24186D-01  -0.11755D-01
Sensitive Instrument 2              10    -0.83179D-01  -0.30810D-01   0.53532D-01   0.11672D-01  -0.24186D-01  -0.11755D-01
Sensitive Instrument 3              11    -0.81348D-01  -0.28602D-01   0.48003D-01   0.96982D-02  -0.17320D-01   0.89383D-03
Sensitive Instrument 4              12    -0.81702D-01  -0.28443D-01   0.52393D-01   0.97266D-02  -0.17404D-01   0.79420D-03
Sensitive Instrument 5              13    -0.79246D-01  -0.27115D-01   0.51275D-01   0.97319D-02  -0.17452D-01   0.78936D-03

MODE#100/100, Frequency (rad/sec), Damping (zeta), Generalized Mass=    757.68       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the  8 Force Application Points
RCS Jet #1    (+X)                  21     0.12959D+00  -0.80308D-01   0.16701D-01   0.43466D-03   0.31043D-01   0.24032D-01
RCS Jet #2    (+X)                  22    -0.23117D-02  -0.16786D-01  -0.16966D-01  -0.28728D-01  -0.10344D-01   0.25147D-01
RCS Jet #3    (+Y)                  23     0.11741D-01   0.21086D-01   0.46611D-01  -0.12283D-01  -0.73340D-01   0.48228D-01
RCS Jet #4    (-Y)                  24     0.21151D-01   0.22927D-01   0.21770D-01  -0.10513D-01  -0.15833D-01   0.45348D-01
RCS Jet #5    (-Y)                  25    -0.73636D-01  -0.19871D-01  -0.34991D-01  -0.32791D-01  -0.26497D-01   0.17728D+00
RCS Jet #6    (+Y)                  26    -0.38870D-01   0.19033D-01   0.12484D-01  -0.32418D-01  -0.62119D-03  -0.13522D+00
RCS Jet #7    (+X)                  27    -0.76721D-01   0.68857D-01  -0.36629D+00  -0.41960D+00  -0.46074D+00  -0.50005D+00
RCS Jet #8    (+X)                  28    -0.23015D+00   0.19751D+00  -0.35591D+00  -0.41959D+00  -0.46069D+00  -0.50014D+00

                              Node Numb    Modal Data at the  6 Torque Application Points
Reaction Wheel #1 Spin Axis         17    -0.18868D-01   0.89453D-02   0.94723D-01  -0.11853D+00   0.24204D+00  -0.13494D+00
Reaction Wheel #2 Spin Axis         18     0.24605D-01   0.25811D-01  -0.35267D-02   0.87178D-01  -0.76992D-01  -0.16236D+00
Reaction Wheel #3 Spin Axis         19     0.20097D-01  -0.95330D-02  -0.28061D-01  -0.15535D+00  -0.99046D-02   0.13471D+00
Cryo Cooler Pump                     8    -0.55584D-02   0.39418D-01   0.13747D-01   0.28751D-01   0.17084D-01   0.23311D-01
Cryo Cooler Pump                     8    -0.55584D-02   0.39418D-01   0.13747D-01   0.28751D-01   0.17084D-01   0.23311D-01
Cryo Cooler Pump                     8    -0.55584D-02   0.39418D-01   0.13747D-01   0.28751D-01   0.17084D-01   0.23311D-01

                              Node Numb    Modal Data at the  2 Linear Translation Measurement Points
Accelerometers                       7     0.21218D-01  -0.22278D-02   0.62360D-02   0.62009D-02   0.91174D-02  -0.92855D-02
Accelerometers                       7     0.21218D-01  -0.22278D-02   0.62360D-02   0.62009D-02   0.91174D-02  -0.92855D-02

                              Node Numb    Modal Data at the 13 Rotation Measurement Points
Inertial Attitude Sensors            6     0.14113D-01   0.73379D-02   0.84244D-02   0.47779D-02   0.44292D-02  -0.95029D-02
Inertial Attitude Sensors            6     0.14113D-01   0.73379D-02   0.84244D-02   0.47779D-02   0.44292D-02  -0.95029D-02
Inertial Attitude Sensors            6     0.14113D-01   0.73379D-02   0.84244D-02   0.47779D-02   0.44292D-02  -0.95029D-02
Inertial Attitude Sensors            6     0.14113D-01   0.73379D-02   0.84244D-02   0.47779D-02   0.44292D-02  -0.95029D-02
Inertial Attitude Sensors            6     0.14113D-01   0.73379D-02   0.84244D-02   0.47779D-02   0.44292D-02  -0.95029D-02
Inertial Attitude Sensors            6     0.14113D-01   0.73379D-02   0.84244D-02   0.47779D-02   0.44292D-02  -0.95029D-02
Second Mirror                        9     0.14033D-01   0.16194D-01   0.14733D-01   0.25355D-01   0.16620D-01   0.22958D-01
Second Mirror                        9     0.14033D-01   0.16194D-01   0.14733D-01   0.25355D-01   0.16620D-01   0.22958D-01
Sensitive Instrument 2              10     0.44324D-01   0.31693D-02   0.23221D-01   0.75320D-02   0.10326D-01  -0.80479D-02
Sensitive Instrument 2              10     0.44324D-01   0.31693D-02   0.23221D-01   0.75320D-02   0.10326D-01  -0.80479D-02
Sensitive Instrument 3              11     0.30749D-01  -0.25383D-02   0.11551D-01   0.48620D-02   0.51306D-02  -0.12821D-01
Sensitive Instrument 4              12     0.34068D-01  -0.40969D-02   0.12163D-01   0.52895D-02   0.57122D-02  -0.12392D-01
Sensitive Instrument 5              13     0.33265D-01  -0.25515D-02   0.12529D-01   0.52900D-02   0.57424D-02  -0.12395D-01

Inertial Coupling Coefficients (H-Parameters) File Name for the   4 gimbaling bodies     :  Surveillance-Sat.Hpr
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Rigid-Body Spacecraft with Gimbaling Telescope and Reaction Wheels (6-modes)                               
System                                                                                          
rigid_body.m                                                                         
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Flex Spacecraft with Gimbaling Telescope and Reaction Wheels (67-modes)                                
System                                                                                          
flex67.m                                                                         
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Flex Spacecraft with Gimbaling Telescope and Reaction Wheels (61-Only Flex)                                
System                                                                                          
flex61.m                                                                         
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Flex Spacecraft with Gimbaling Telescope and Reaction Wheels (100-modes)                                
System                                                                                          
flex100.m                                                                         
---------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
